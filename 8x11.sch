# EAGLE board 8x11 (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DIO03  (via drill 0.61)  (3 unrouted) (continued)
  Top 0.254: IC34.2 19.68,36.21 v19.68,29.23 19.68,17.16 v20.32,16.53 | v59.05,31.77 59.05,33.67 IC35.18 | v2.54,108.6 2.54,71.14 3.81,69.86 3.81,69.23 1.91,67.33 1.91,39.38 v3.81,37.48 | v25.4,115.58 IC13.9 | v53.34,172.73 53.34,175.27 IC40.15
  Bottom 0.254: IC13.9 27.3,117.49 35.56,117.49 37.47,119.39 38.73,119.39 39.37,118.76 39.37,118.12 40.01,117.49 48.9,117.49 49.53,118.12 49.53,121.3 51.44,121.3 IC14.9 | v19.68,29.23 36.2,29.23 37.47,30.5 RS08.33 43.81,30.5 45.09,31.77 v59.05,31.77 | v20.32,16.53 31.11,16.53 32.38,17.8 SV1.8 | v25.4,115.58 9.53,115.58 v2.54,108.6 | v3.81,37.48 6.99,34.3 12.06,34.3 15.88,38.12 IC34.2 | v53.34,172.73 52.07,171.46 49.53,171.46 39.37,161.3 38.73,161.3 37.47,160.03 SV3.8 | IC43.13 273.05,40.66 273.05,56.53 254.63,56.53 254,57.16 251.46,57.16 246.38,62.24 243.84,62.24 240.03,66.06 229.24,66.06 219.71,56.53 219.71,49.55 221.62,49.55 222.88,48.27 RF08A.33 | IC45.13 274.95,153.05 274.95,184.8 220.34,184.8 219.07,183.53 219.07,158.76 221.62,158.76 222.88,160.03 RF08B.33
DIO04  (via drill 0.61)  (3 unrouted)
  Top 0.254: 36.83,21.61 34.92,21.61 33.66,20.34 SV1.10 | 36.83,21.61 v36.83,47.01 | v27.3,82.56 27.3,67.96 IC26.17 | v56.52,82.56 56.52,71.77 IC28.3 | IC15.2 71.12,106.7 69.85,105.42 v69.85,82.56 69.85,67.33 71.75,67.33 72.39,66.69 72.39,36.84 v69.85,36.84 | 36.83,21.61 36.83,15.26 v38.1,13.99 | v48.26,12.71 48.9,13.35 48.9,31.13 52.07,34.3 54.61,34.3 55.88,33.04 56.52,33.04 56.52,33.67 57.15,34.3 57.15,34.94 v56.52,35.58 | v88.9,186.7 90.17,185.43 IC56.4 | v81.28,187.97 85.09,191.78 85.09,193.69 80.01,198.77 52.07,198.77 v47.62,194.32 | v45.09,191.78 45.09,169.56 46.35,168.29 47.62,168.29 v48.26,168.92
  Bottom 0.254: v36.83,47.01 43.81,47.01 44.45,46.37 44.45,45.1 45.72,43.83 RS08.24 | v27.3,82.56 v56.52,82.56 57.15,83.2 57.78,83.2 58.42,82.56 v69.85,82.56 | v38.1,13.99 45.09,13.99 46.35,12.71 v48.26,12.71 | v56.52,35.58 57.78,36.84 v69.85,36.84 | v88.9,186.7 82.55,186.7 v81.28,187.97 | v47.62,194.32 v45.09,191.78 | v48.26,168.92 SV3.10 | IC42.21 232.41,35.58 231.78,34.94 224.79,34.94 224.16,34.3 222.88,34.3 221.62,35.58 RF08A.24 | IC39.21 232.41,147.33 231.78,146.7 224.79,146.7 224.16,146.06 222.88,146.06 221.62,147.33 RF08B.24
DIO05  (via drill 0.61)  (3 unrouted)
  Top 0.254: v30.48,41.92 30.48,54.62 27.3,57.8 27.3,59.07 IC26.15 22.86,58.44 22.86,42.56 23.5,41.92 23.5,37.48 24.13,36.84 23.5,36.21 v23.5,24.14 | 57.15,59.7 57.15,42.56 v57.78,41.92 | 57.15,59.7 IC28.5 | v59.05,110.5 59.05,106.06 59.69,105.42 59.69,81.3 57.15,78.75 57.15,59.7 | v93.98,194.32 96.52,191.78 100.33,191.78 102.87,189.24 102.87,179.08 IC56.13 | v81.92,193.05 81.92,194.32 78.74,197.5 52.07,197.5 v50.16,195.59 | v33.02,168.92 SV3.12
  Bottom 0.254: v30.48,41.92 43.81,41.92 45.09,40.66 RS08.26 48.9,40.66 50.16,41.92 v57.78,41.92 | v59.05,110.5 67.31,110.5 IC15.1 | v23.5,24.14 31.11,24.14 32.38,22.88 SV1.12 | v93.98,194.32 83.19,194.32 v81.92,193.05 | v50.16,195.59 18.41,195.59 16.51,193.69 16.51,191.15 20.95,186.7 20.32,186.07 20.32,173.37 22.86,170.83 22.86,169.56 23.5,168.92 v33.02,168.92 | IC42.20 232.41,38.12 231.78,37.48 224.79,37.48 224.16,36.84 222.88,36.84 221.62,38.12 RF08A.26 | IC39.20 232.41,149.88 231.78,149.24 224.79,149.24 224.16,148.6 222.88,148.6 221.62,149.88 RF08B.26
DIO06  (via drill 0.61)  (3 unrouted)
  Top 0.254: v26.67,43.83 27.3,44.47 27.3,53.99 IC26.13 | v40.01,44.47 40.64,43.83 v40.64,36.84 40.64,25.41 v39.37,24.14 | v56.52,37.48 56.52,55.26 IC28.7 | v65.41,106.7 65.41,108.6 67.31,110.5 67.31,114.31 71.12,118.12 IC15.13 | v50.8,106.7 49.53,105.42 49.53,89.55 47.62,87.64 47.62,76.85 49.53,74.95 49.53,61.61 v48.9,60.98 | v87.63,182.89 87,182.26 85.09,182.26 78.11,175.27 66.04,175.27 64.77,174 62.23,174 59.69,171.46 57.15,171.46 46.99,161.3 46.35,161.3 45.09,160.03 SV3.14
  Bottom 0.254: v26.67,43.83 39.37,43.83 v40.01,44.47 | v40.64,36.84 43.81,36.84 | 43.81,36.84 45.09,38.12 RS08.28 | v56.52,37.48 55.88,36.84 43.81,36.84 | v50.8,106.7 v65.41,106.7 | v48.9,60.98 51.44,58.44 IC28.7 | v39.37,24.14 34.92,24.14 33.66,25.41 SV1.14 | v87.63,182.89 88.9,184.16 93.98,184.16 96.52,186.7 100.33,186.7 100.97,186.07 100.97,184.8 105.41,180.35 IC47.6 | IC42.19 232.41,40.66 231.78,40.02 224.79,40.02 224.16,39.38 222.88,39.38 221.62,40.66 RF08A.28 | IC39.19 232.41,152.41 231.78,151.78 224.79,151.78 224.16,151.14 222.88,151.14 221.62,152.41 RF08B.28
DIO07  (via drill 0.61)  (3 unrouted)
  Top 0.254: v69.85,106.7 69.85,114.31 73.66,118.12 IC15.12 | v53.34,100.98 52.7,100.34 52.7,98.44 52.07,97.81 52.07,80.03 49.53,77.48 49.53,76.22 50.16,75.58 50.16,54.62 v49.53,53.99 | v33.02,51.45 33.02,45.1 31.75,43.83 31.75,29.86 33.02,28.59 SV1.16 | v50.8,35.58 51.44,36.21 51.44,38.75 52.07,39.38 55.88,39.38 55.88,50.81 IC28.9 | v95.89,167.02 v95.89,169.56 | v84.45,163.84 84.45,161.3 81.28,158.13 65.41,158.13 64.77,158.76 62.87,158.76 v61.59,157.49
  Bottom 0.254: 33.02,52.09 35.56,52.09 36.83,50.81 41.27,50.81 42.55,52.09 48.9,52.09 50.16,53.36 | 33.02,52.09 27.94,52.09 26.67,50.81 IC26.11 | 50.16,53.36 IC28.9 | v69.85,106.7 69.85,102.25 67.31,102.25 66.67,101.61 59.69,101.61 59.05,102.25 54.61,102.25 v53.34,100.98 | 50.16,53.36 v49.53,53.99 | v33.02,51.45 33.02,52.09 | v50.8,35.58 RS08.30 | v95.89,169.56 97.79,171.46 101.6,171.46 104.14,174 107.95,174 109.22,175.27 IC47.13 | v95.89,167.02 92.71,163.84 v84.45,163.84 | v61.59,157.49 60.33,156.22 48.9,156.22 48.26,156.86 48.26,158.13 46.99,159.4 SV3.16 | IC42.18 232.41,43.2 231.14,41.92 222.88,41.92 221.62,43.2 RF08A.30 | IC39.18 232.41,154.95 231.14,153.68 222.88,153.68 221.62,154.95 RF08B.30
DIO08  (via drill 0.61)  (3 unrouted)
  Top 0.254: v29.21,31.77 v29.21,54.62 | v49.53,33.04 49.53,51.45 v50.16,52.09 50.8,52.72 v50.8,77.48 | v61.59,78.75 61.59,121.3 74.3,121.3 IC15.11 | v116.2,165.75 115.57,166.38 113.03,166.38 111.76,167.65 107.95,167.65 100.97,160.67 95.25,160.67 90.81,156.22 64.14,156.22 v63.5,156.86
  Bottom 0.254: v29.21,54.62 20.32,54.62 19.05,55.9 IC26.8 | v29.21,31.77 30.48,30.5 SV1.18 33.66,30.5 34.92,31.77 43.81,31.77 45.09,33.04 RS08.32 v49.53,33.04 | v50.16,52.09 58.42,52.09 59.69,53.36 IC28.12 | v61.59,78.75 60.33,77.48 v50.8,77.48 | v116.2,165.75 116.84,166.38 121.92,166.38 123.83,168.29 134.62,168.29 140.97,174.64 140.97,180.35 146.05,185.43 IC48.4 | v63.5,156.86 61.59,158.76 51.44,158.76 50.16,160.03 SV3.18 | IC42.17 232.41,45.73 231.14,44.47 222.88,44.47 221.62,45.73 RF08A.32 | IC39.17 232.41,157.49 231.14,156.22 222.88,156.22 221.62,157.49 RF08B.32
DIO09  (via drill 0.61)  (3 unrouted)
  Top 0.254: v77.47,126.38 77.47,121.94 78.74,120.67 IC15.10 | v12.7,91.45 13.97,90.19 13.97,66.06 12.7,64.78 14.61,62.88 v14.61,60.98 | v30.48,33.04 v30.48,38.12 | v27.94,38.12 v27.94,55.9 | v143.51,175.91 143.51,178.45 142.24,179.72 v133.35,179.72 | v107.31,163.21 104.78,163.21 101.6,160.03 95.89,160.03 v93.98,158.13 | v81.28,159.4 v62.23,159.4 | v54.61,163.21 52.07,160.67 SV3.20
  Bottom 0.254: RS08.29 42.55,35.58 41.27,34.3 34.92,34.3 33.66,33.04 SV1.20 v30.48,33.04 | 29.21,57.16 58.42,57.16 59.69,58.44 IC28.14 | 29.21,57.16 26.67,59.7 20.32,59.7 19.05,60.98 IC26.6 v14.61,60.98 | v77.47,126.38 76.83,127.02 7.62,127.02 1.27,120.67 1.27,91.45 v12.7,91.45 | v30.48,38.12 v27.94,38.12 | v27.94,55.9 29.21,57.16 | v143.51,175.91 144.15,176.54 148.59,176.54 149.86,175.27 IC48.13 | v133.35,179.72 132.08,179.72 121.28,168.92 116.84,168.92 111.76,163.84 107.95,163.84 v107.31,163.21 | v93.98,158.13 82.55,158.13 v81.28,159.4 | v62.23,159.4 59.05,162.57 55.24,162.57 v54.61,163.21 | IC42.15 247.65,43.2 246.38,44.47 232.41,44.47 231.14,43.2 RF08A.29 | IC39.15 247.65,154.95 246.38,156.22 232.41,156.22 231.14,154.95 RF08B.29
DIO10  (via drill 0.61)  (3 unrouted)
  Top 0.254: v12.7,80.66 v12.7,66.06 | v25.4,92.09 26.67,93.36 v26.67,107.97 | v78.74,109.23 80.01,110.5 80.01,116.86 81.28,118.12 IC15.9 | v64.77,63.52 64.14,64.15 v64.14,109.23 | v48.26,39.38 47.62,40.02 47.62,61.61 v48.26,62.24 | v135.89,161.94 118.75,161.94 v118.11,161.3 | v106.68,158.76 v109.22,161.3 | v67.31,161.3 62.87,161.3 62.23,161.94 57.15,161.94 55.24,160.03 SV3.22 | v157.48,180.35 IC49.6
  Bottom 0.254: SV1.22 33.66,35.58 34.92,36.84 39.37,36.84 40.64,38.12 RS08.27 43.81,38.12 45.09,39.38 v48.26,39.38 | v12.7,80.66 24.13,92.09 v25.4,92.09 | v26.67,107.97 27.94,109.23 v64.14,109.23 v78.74,109.23 | v12.7,66.06 IC26.4 | v64.77,63.52 IC28.16 55.88,63.52 54.61,62.24 v48.26,62.24 | v157.48,180.35 156.21,179.08 145.41,179.08 142.24,175.91 142.24,173.37 144.78,170.83 144.78,165.75 142.24,163.21 140.34,165.11 139.06,165.11 v135.89,161.94 | v109.22,161.3 v118.11,161.3 | v106.68,158.76 105.41,158.76 102.87,161.3 80.64,161.3 79.38,162.57 68.58,162.57 v67.31,161.3 | IC42.14 247.65,40.66 246.38,41.92 232.41,41.92 231.14,40.66 RF08A.27 | IC39.14 247.65,152.41 246.38,153.68 232.41,153.68 231.14,152.41 RF08B.27
DIO11  (via drill 0.61)  (3 unrouted)
  Top 0.254: v85.09,93.36 85.72,94 85.72,116.22 83.82,118.12 IC15.8 | v66.04,93.36 65.41,92.72 v65.41,68.59 | v21.59,39.38 21.59,62.88 20.95,63.52 20.95,69.23 v21.59,69.86 | v144.78,190.51 146.05,189.24 148.59,189.24 153.67,184.16 156.21,184.16 158.75,181.62 163.83,181.62 165.1,180.35 IC49.15 | v72.39,187.34 67.94,187.34 64.77,184.16 62.23,184.16 60.33,182.26 60.33,174.64 59.69,174 57.15,174 49.53,166.38 v48.9,166.38
  Bottom 0.254: RS08.25 42.55,40.66 41.27,39.38 34.92,39.38 33.66,38.12 SV1.24 32.38,38.12 31.11,39.38 v21.59,39.38 | IC26.2 19.05,71.14 20.32,69.86 v21.59,69.86 58.42,69.86 59.69,68.59 IC28.18 v65.41,68.59 | v66.04,93.36 v85.09,93.36 | v144.78,190.51 144.78,192.42 138.43,198.77 89.53,198.77 87,196.23 80.01,196.23 79.38,196.86 78.11,196.86 72.39,191.15 v72.39,187.34 | v48.9,166.38 48.9,163.84 51.44,161.3 55.24,161.3 56.52,160.03 SV3.24 | IC42.13 247.65,38.12 246.38,39.38 225.43,39.38 224.16,38.12 RF08A.25 | IC39.13 247.65,149.88 246.38,151.14 225.43,151.14 224.16,149.88 RF08B.25
DIOEVEN  (via drill 0.61)  (2 unrouted)
  Top 0.254: v50.16,30.5 50.16,29.23 54.61,29.23 55.24,28.59 55.24,22.24 IC35.9 | v11.43,86.38 11.43,114.31 15.24,118.12 IC13.13 | IC43.18 250.82,43.2 250.82,43.83 250.19,44.47 241.94,44.47 241.94,64.15 240.03,66.06 219.71,66.06 219.71,50.18 220.98,48.91 RF08A.34 | IC45.18 250.82,154.95 250.82,155.59 250.19,156.22 237.49,156.22 237.49,166.38 234.95,168.92 234.95,170.19 234.31,170.83 222.25,170.83 222.25,167.02 221.62,166.38 219.71,166.38 219.71,161.94 220.98,160.67 RF08B.34
  Bottom 0.254: v50.16,30.5 RS08.34 | v11.43,86.38 1.27,76.22 1.27,19.07 48.9,19.07 50.16,20.34 IC35.9
DMA00  (via drill 0.61)  (3 unrouted)
  Top 0.254: v150.5,5.73 150.5,10.81 IC38.8 | v28.57,83.83 28.57,82.56 27.94,81.93 27.94,59.07 v31.11,55.9 | v109.22,38.12 110.49,36.84 110.49,7 114.3,7 117.47,10.18 DMA0-3.7 | v78.11,76.22 v78.11,50.81 | v62.87,91.45 v62.87,78.75 | v34.29,92.72 33.02,91.45 SV2.1 | v29.21,196.86 34.29,191.78 36.83,191.78 39.37,189.24 IC33.4 | v194.94,198.13 199.39,193.69 199.39,177.18 188.59,166.38 173.99,166.38 IC49.11 | v122.56,158.13 123.19,157.49 SV4.1 | v109.86,158.13 107.31,158.13 106.68,157.49 105.41,158.76 v95.89,158.76 | v80.64,168.92 v90.17,159.4 | v88.27,193.05 v83.82,197.5
  Bottom 0.254: v150.5,5.73 127.64,5.73 123.19,10.18 DMA0-3.7 | 37.47,54.62 36.2,55.9 SV2.24 | 37.47,54.62 43.81,54.62 45.09,53.36 RS08.16 | v31.11,55.9 32.38,54.62 37.47,54.62 | v28.57,83.83 SV2.1 | v109.22,38.12 101.6,45.73 83.19,45.73 v78.11,50.81 | v78.11,76.22 75.56,78.75 v62.87,78.75 | v62.87,91.45 62.23,92.09 38.73,92.09 38.1,92.72 v34.29,92.72 | v29.21,196.86 38.73,196.86 41.27,199.4 83.82,199.4 | 83.82,199.4 193.68,199.4 v194.94,198.13 | v109.86,158.13 v122.56,158.13 | v95.89,158.76 94.61,158.76 93.98,159.4 v90.17,159.4 | v80.64,168.92 78.11,168.92 77.47,169.56 77.47,170.83 78.74,172.1 78.74,175.91 77.47,177.18 77.47,187.34 81.92,191.78 87,191.78 v88.27,193.05 | v83.82,197.5 83.82,199.4 | SV4.24 155.57,160.03 161.93,166.38 165.1,166.38 168.91,170.19 IC49.11 | RF08A.16 221.62,25.41 222.88,24.14 224.16,24.14 224.79,24.78 231.78,24.78 232.41,25.41 IC42.25 235.59,25.41 236.85,24.14 252.73,24.14 254,25.41 IC43.25 | RF08B.16 221.62,137.17 222.88,135.9 224.16,135.9 224.79,136.54 231.78,136.54 232.41,137.17 IC39.25 235.59,137.17 236.85,135.9 254,135.9 255.27,137.17 IC45.25
DMA01  (via drill 0.61)  (3 unrouted)
  Top 0.254: v134.62,17.8 134.62,6.36 128.27,6.36 DMA0-3.6 | v76.2,47.01 77.47,45.73 77.47,13.35 v78.74,12.08 | v67.31,83.83 67.31,66.69 69.22,64.78 69.22,60.34 68.58,59.7 68.58,48.91 v69.22,48.27 | v71.12,161.3 v66.04,166.38 | v104.14,157.49 105.41,156.22 127.64,156.22 128.91,157.49 SV4.3
  Bottom 0.254: v134.62,17.8 135.89,16.53 149.86,16.53 151.13,17.8 IC38.6 | v76.2,47.01 70.48,47.01 v69.22,48.27 59.05,48.27 58.42,47.64 46.99,47.64 46.35,48.27 RS08.20 | v78.74,12.08 80.01,10.81 118.75,10.81 120.65,12.71 DMA0-3.6 | v67.31,83.83 56.52,83.83 55.88,83.2 45.72,83.2 43.81,85.11 26.04,85.11 26.04,82.56 27.3,81.3 SV2.3 | v66.04,166.38 59.69,166.38 56.52,169.56 56.52,172.1 52.07,176.54 48.26,176.54 46.99,175.27 IC33.13 | v71.12,161.3 78.11,161.3 82.55,156.86 103.5,156.86 v104.14,157.49 | RF08A.20 221.62,30.5 222.88,29.23 224.16,29.23 224.79,29.86 231.78,29.86 232.41,30.5 IC42.23 235.59,30.5 236.85,29.23 252.73,29.23 254,30.5 IC43.23 | RF08B.20 221.62,142.25 222.88,140.98 224.16,140.98 224.79,141.62 231.78,141.62 232.41,142.25 IC39.23 235.59,142.25 236.85,140.98 254,140.98 255.27,142.25 IC45.23
DMA02  (via drill 0.61)  (3 unrouted)
  Top 0.254: v44.45,78.75 44.45,57.8 45.72,56.53 RS08.14 | v102.87,20.97 102.87,40.66 104.14,41.92 104.14,62.88 105.41,64.15 105.41,86.38 102.87,88.92 v102.87,89.55 | v50.8,89.55 48.9,87.64 v48.9,80.66 | v78.74,179.72 v69.85,179.72 | v86.36,174 89.53,170.83 89.53,169.56 v92.71,166.38 | v104.14,161.3 106.68,161.3 109.22,163.84 113.03,163.84 v114.3,162.57
  Bottom 0.254: IC38.4 151.13,22.88 149.86,21.61 124.46,21.61 123.19,22.88 DMA0-3.2 120.65,22.88 118.75,20.97 v102.87,20.97 | v44.45,78.75 43.18,80.03 | 43.18,80.03 34.92,80.03 33.66,78.75 SV2.5 | v102.87,89.55 102.23,88.92 78.11,88.92 76.2,90.82 74.93,90.82 73.03,88.92 51.44,88.92 v50.8,89.55 | v48.9,80.66 48.26,80.03 43.18,80.03 | v69.85,179.72 69.22,179.72 64.77,184.16 57.15,184.16 55.88,185.43 IC40.4 | v78.74,179.72 84.45,174 v86.36,174 | v92.71,166.38 94.61,168.29 97.16,168.29 v104.14,161.3 | v114.3,162.57 122.56,162.57 123.83,161.3 130.18,161.3 130.81,160.67 130.81,159.4 132.08,158.13 SV4.5 | RF08A.14 221.62,22.88 222.88,21.61 224.16,21.61 224.79,22.24 231.78,22.24 232.41,22.88 IC42.26 234.95,22.88 236.22,21.61 252.73,21.61 254,22.88 IC43.26 | RF08B.14 221.62,134.63 222.88,133.36 224.16,133.36 224.79,134 231.78,134 232.41,134.63 IC39.26 234.95,134.63 236.22,133.36 254,133.36 255.27,134.63 IC45.26
DMA03  (via drill 0.61)  (3 unrouted)
  Top 0.254: v48.26,73.67 47.62,73.04 47.62,62.88 46.99,62.24 46.99,60.34 45.72,59.07 RS08.12 45.72,57.8 46.99,56.53 46.99,14.62 47.62,13.99 47.62,13.35 46.99,12.71 v46.99,6.36 | v124.46,30.5 124.46,22.88 DMA0-3.3 | v64.14,6.36 67.31,3.19 85.72,3.19 v85.72,14.62 | v114.3,16.53 118.11,20.34 v118.11,29.23 | v67.31,173.37 68.58,172.1 v74.93,172.1 | v77.47,172.1 80.01,172.1 87,165.11 101.6,165.11 v104.78,168.29 | v107.31,165.75 111.12,165.75 111.76,165.11 114.3,165.11 116.84,162.57 125.09,162.57 v125.73,163.21
  Bottom 0.254: v48.26,73.67 46.99,74.95 34.92,74.95 33.66,76.22 SV2.7 | IC38.2 151.13,27.96 149.86,29.23 125.73,29.23 v124.46,30.5 119.38,30.5 v118.11,29.23 | v46.99,6.36 v64.14,6.36 | v85.72,14.62 88.27,17.16 113.67,17.16 v114.3,16.53 | v67.31,173.37 66.67,174 62.23,174 60.96,175.27 IC40.13 | v77.47,172.1 v74.93,172.1 | v104.78,168.29 v107.31,165.75 | v125.73,163.21 130.81,163.21 133.35,160.67 133.35,159.4 134.62,158.13 SV4.7 | RF08A.12 221.62,20.34 222.88,19.07 224.16,19.07 224.79,19.7 231.78,19.7 232.41,20.34 IC42.27 234.95,20.34 236.22,19.07 252.73,19.07 254,20.34 IC43.27 | RF08B.12 221.62,132.09 222.88,130.82 224.16,130.82 224.79,131.46 231.78,131.46 232.41,132.09 IC39.27 234.95,132.09 236.22,130.82 254,130.82 255.27,132.09 IC45.27
DMA04  (via drill 0.61)  (3 unrouted)
  Top 0.254: v31.11,60.98 31.11,72.41 32.38,73.67 SV2.9 | v123.83,40.66 123.83,42.56 DMA4-7.7 | v138.43,40.02 142.88,44.47 v142.88,45.73 | v104.14,88.92 106.05,87.01 106.05,53.36 v105.41,52.72 | v104.14,176.54 v104.14,182.89 | v102.87,171.46 v102.87,174 | v107.31,164.48 113.67,164.48 118.11,160.03 121.92,160.03 123.19,161.3 132.72,161.3 133.35,160.67 133.35,159.4 133.99,158.76 135.25,158.76 136.53,157.49 SV4.9
  Bottom 0.254: v31.11,60.98 32.38,59.7 33.66,59.7 34.29,60.34 34.29,61.61 34.92,62.24 39.37,62.24 40.64,60.98 RS08.9 | v123.83,40.66 124.46,40.02 v138.43,40.02 | v142.88,45.73 149.86,45.73 151.13,47.01 IC31.8 | v104.14,88.92 103.5,88.28 74.93,88.28 74.3,87.64 44.45,87.64 43.18,88.92 38.73,88.92 37.47,87.64 22.86,87.64 22.86,83.2 32.38,73.67 SV2.9 | v105.41,52.72 106.05,52.09 115.57,52.09 120.02,47.64 120.02,45.1 121.28,45.1 DMA4-7.7 | v104.14,182.89 104.14,185.43 100.33,189.24 97.79,189.24 96.52,190.51 IC56.2 | v104.14,176.54 104.14,175.27 v102.87,174 | v102.87,171.46 102.87,168.92 v107.31,164.48 | IC43.5 269.24,17.8 267.97,19.07 254,19.07 253.37,18.43 250.82,18.43 250.19,17.8 IC42.5 248.28,18.43 235.59,18.43 234.95,19.07 225.43,19.07 224.16,17.8 RF08A.9 | IC45.5 270.51,129.55 269.24,130.82 255.27,130.82 254.63,130.19 250.82,130.19 250.19,129.55 IC39.5 248.28,130.19 235.59,130.19 234.95,130.82 225.43,130.82 224.16,129.55 RF08B.9
DMA05  (via drill 0.61)  (3 unrouted)
  Top 0.254: v36.83,67.33 36.83,69.86 34.92,69.86 33.66,71.14 SV2.11 | v40.01,67.33 40.64,66.69 40.64,63.52 41.91,62.24 41.91,60.34 43.18,59.07 RS08.11 | v125.73,52.09 125.73,50.81 DMA4-7.6 | v21.59,74.95 v21.59,72.41 | v3.81,74.95 4.45,74.31 4.45,57.16 3.81,56.53 3.81,53.99 4.45,53.36 4.45,52.09 3.81,51.45 3.81,38.75 5.08,37.48 v5.08,17.8 | v67.31,5.73 69.22,3.83 74.93,3.83 v74.93,11.45 | v91.44,15.89 92.71,17.16 v92.71,52.72 | IC56.11 104.14,170.19 105.41,171.46 110.49,171.46 114.94,167.02 117.47,167.02 118.11,166.38 123.83,166.38 127,163.21 135.89,163.21 137.16,161.94 135.89,160.67 135.89,159.4 136.53,158.76 137.79,158.76 139.06,157.49 SV4.11
  Bottom 0.254: v36.83,67.33 v40.01,67.33 | 127,53.36 v125.73,52.09 | 127,53.36 149.86,53.36 151.13,52.09 IC31.6 | v21.59,72.41 26.67,72.41 27.3,71.77 31.75,71.77 32.38,71.14 SV2.11 | v3.81,74.95 v21.59,74.95 | v5.08,17.8 15.88,7 44.45,7 46.35,5.09 66.67,5.09 v67.31,5.73 | v74.93,11.45 76.83,13.35 88.9,13.35 v91.44,15.89 | v92.71,52.72 93.98,53.99 110.49,53.99 111.12,54.62 119.38,54.62 120.65,53.36 127,53.36 | IC45.6 270.51,132.09 269.24,133.36 255.27,133.36 254.63,132.73 250.82,132.73 250.19,132.09 IC39.6 236.22,132.09 234.95,133.36 225.43,133.36 224.16,132.09 RF08B.11 | IC43.6 269.24,20.34 267.97,21.61 254,21.61 253.37,20.97 250.82,20.97 250.19,20.34 IC42.6 236.22,20.34 234.95,21.61 225.43,21.61 224.16,20.34 RF08A.11
DMA06  (via drill 0.61)  (3 unrouted)
  Top 0.254: v40.01,55.9 38.1,57.8 v38.1,64.78 | v29.84,68.59 30.48,69.23 30.48,85.74 v31.11,86.38 | v118.11,85.11 118.75,84.47 118.75,66.69 118.11,66.06 v118.11,56.53 | IC47.4 109.22,187.97 109.22,193.05 110.49,194.32 113.03,191.78 115.57,191.78 118.11,194.32 142.88,194.32 143.51,193.69 143.51,181.62 144.78,180.35 144.78,175.91 140.97,172.1 140.97,168.29 143.51,165.75 143.51,159.4 142.24,158.13 SV4.13
  Bottom 0.254: v38.1,64.78 34.92,64.78 34.29,65.42 34.29,67.96 33.02,67.96 SV2.13 v29.84,68.59 | v40.01,55.9 RS08.13 | IC31.4 149.22,57.16 147.96,55.9 124.46,55.9 123.19,57.16 DMA4-7.2 118.75,57.16 v118.11,56.53 | v31.11,86.38 31.75,85.74 79.38,85.74 80.01,86.38 116.84,86.38 v118.11,85.11 | IC45.7 270.51,134.63 269.24,135.9 255.27,135.9 254.63,135.27 250.82,135.27 250.19,134.63 IC39.7 236.85,134.63 235.59,135.9 225.43,135.9 224.16,134.63 RF08B.13 | IC43.7 269.24,22.88 267.97,24.14 254,24.14 253.37,23.51 250.82,23.51 250.19,22.88 IC42.7 236.85,22.88 235.59,24.14 225.43,24.14 224.16,22.88 RF08A.13
DMA07  (via drill 0.61)  (3 unrouted)
  Top 0.254: v40.01,53.36 37.47,55.9 37.47,63.52 36.2,64.78 | 36.2,64.78 33.02,64.78 SV2.15 | v149.22,64.78 v149.22,62.24 | DMA4-7.3 125.09,57.8 v125.09,62.88 126.36,64.15 126.36,73.04 125.73,73.67 125.73,83.83 v124.46,85.11 | 36.2,64.78 38.1,66.69 v38.1,87.01 | v137.79,162.57 128.91,171.46 123.83,171.46 121.28,168.92 118.11,168.92 116.84,170.19 IC47.11
  Bottom 0.254: v40.01,53.36 RS08.15 | v125.09,62.88 127,64.78 v149.22,64.78 | v149.22,62.24 IC31.2 | v38.1,87.01 38.73,86.38 78.74,86.38 79.38,87.01 118.75,87.01 120.65,85.11 v124.46,85.11 | v137.79,162.57 141.6,162.57 143.51,160.67 143.51,159.4 144.78,158.13 SV4.15 | IC45.8 270.51,137.17 269.24,138.44 251.46,138.44 250.19,137.17 IC39.8 246.38,137.17 245.11,138.44 225.43,138.44 224.16,137.17 RF08B.15 | IC43.8 269.24,25.41 267.97,26.69 251.46,26.69 250.19,25.41 IC42.8 246.38,25.41 245.11,26.69 225.43,26.69 224.16,25.41 RF08A.15
DMA08  (via drill 0.61)  (3 unrouted)
  Top 0.254: v41.27,52.09 42.55,50.81 RS08.17 | v38.73,52.09 36.83,53.99 36.83,61.61 36.2,62.24 34.92,62.24 33.66,63.52 SV2.17 | v123.83,82.56 123.83,80.66 DMA8-11.7 | v23.5,64.78 22.86,65.42 22.86,80.66 28.57,86.38 v28.57,88.92 | v83.82,91.45 85.09,90.19 v85.09,84.47
  Bottom 0.254: v38.73,52.09 v41.27,52.09 | IC24.8 148.59,81.3 147.32,82.56 v123.83,82.56 118.11,82.56 115.57,85.11 85.72,85.11 v85.09,84.47 | v23.5,64.78 31.11,64.78 32.38,63.52 SV2.17 | v28.57,88.92 29.84,90.19 50.16,90.19 50.8,90.82 60.96,90.82 62.23,89.55 72.39,89.55 74.3,91.45 v83.82,91.45 | IC48.2 149.86,190.51 156.21,196.86 197.49,196.86 200.66,193.69 200.66,170.83 186.06,156.22 149.22,156.22 147.96,157.49 SV4.17 | IC45.9 270.51,139.71 269.24,140.98 255.27,140.98 254.63,140.35 250.82,140.35 250.19,139.71 IC39.9 248.28,140.35 236.22,140.35 235.59,140.98 225.43,140.98 224.16,139.71 RF08B.17 | IC43.9 269.24,27.96 267.97,29.23 254,29.23 253.37,28.59 250.82,28.59 250.19,27.96 IC42.9 248.28,28.59 236.22,28.59 235.59,29.23 225.43,29.23 224.16,27.96 RF08A.17
DMA09  (via drill 0.61)  (3 unrouted)
  Top 0.254: v114.3,77.48 114.3,80.03 v115.57,81.3 115.57,128.28 v114.94,128.92 | v81.28,76.85 79.38,74.95 v79.38,72.41 | v59.05,72.41 58.42,71.77 58.42,47.64 v59.05,47.01 | v149.22,87.01 148.59,87.64 v148.59,101.61 | v135.89,101.61 136.53,102.25 136.53,108.6 138.43,110.5 v138.43,128.28 | v34.29,50.81 34.29,59.07 33.02,60.34 SV2.19
  Bottom 0.254: v114.3,77.48 81.92,77.48 v81.28,76.85 | v79.38,72.41 v59.05,72.41 | v59.05,47.01 45.09,47.01 43.81,48.27 RS08.19 40.64,48.27 39.37,49.55 35.56,49.55 v34.29,50.81 | v115.57,81.3 DMA8-11.6 | v149.22,87.01 150.5,87.01 151.13,86.38 IC24.6 | v135.89,101.61 v148.59,101.61 | v138.43,128.28 137.79,128.92 v114.94,128.92 | IC48.11 154.31,169.56 154.31,163.84 151.13,160.67 151.13,159.4 149.86,158.13 SV4.19 | IC45.10 270.51,142.25 269.24,143.52 251.46,143.52 250.19,142.25 IC39.10 247.65,142.25 246.38,143.52 225.43,143.52 224.16,142.25 RF08B.19 | IC43.10 269.24,30.5 267.97,31.77 251.46,31.77 250.19,30.5 IC42.10 247.65,30.5 246.38,31.77 225.43,31.77 224.16,30.5 RF08A.19
DMA10  (via drill 0.61)  (3 unrouted)
  Top 0.254: v40.64,45.73 41.27,46.37 41.27,50.81 40.01,52.09 41.27,53.36 v41.27,58.44 | v50.8,43.2 v50.8,48.91 | v81.28,57.16 82.55,58.44 v82.55,61.61 | v101.6,62.88 104.14,65.42 104.14,81.3 101.6,83.83 v101.6,91.45
  Bottom 0.254: v41.27,58.44 40.01,59.7 34.92,59.7 33.66,58.44 SV2.21 | v40.64,45.73 RS08.21 43.18,45.1 44.45,43.83 44.45,42.56 45.09,41.92 48.9,41.92 50.16,43.2 v50.8,43.2 | IC24.4 151.13,91.45 149.86,90.19 128.27,90.19 127.64,90.82 123.83,90.82 123.19,91.45 DMA8-11.2 v101.6,91.45 | v50.8,48.91 51.44,49.55 57.15,49.55 59.69,52.09 62.23,52.09 67.31,57.16 v81.28,57.16 | v82.55,61.61 83.82,62.88 v101.6,62.88 | IC49.4 164.47,183.53 164.47,169.56 161.93,167.02 160.02,167.02 153.67,160.67 153.67,159.4 152.4,158.13 SV4.21 | 251.46,146.06 250.19,144.79 IC39.11 | 251.46,146.06 269.24,146.06 270.51,144.79 IC45.11 | 251.46,146.06 225.43,146.06 224.16,144.79 RF08B.21 | 251.46,34.3 250.19,33.04 IC42.11 | 251.46,34.3 267.97,34.3 269.24,33.04 IC43.11 | 251.46,34.3 225.43,34.3 224.16,33.04 RF08A.21
DMA11  (via drill 0.61)  (3 unrouted)
  Top 0.254: v31.75,48.27 31.75,53.99 33.02,55.26 SV2.23 | v39.37,48.27 38.73,47.64 38.73,46.37 38.1,45.73 38.1,17.8 v39.37,16.53 | v65.41,19.7 67.31,21.61 67.31,31.77 v69.85,34.3 | v96.52,35.58 103.5,42.56 103.5,63.52 104.78,64.78 104.78,81.93 v104.14,82.56 | v110.49,83.83 114.3,87.64 v114.3,88.28 | IC49.13 158.75,163.84 158.75,156.86 158.12,156.22 156.84,156.22 155.57,157.49 SV4.23
  Bottom 0.254: RS08.23 27.3,43.2 26.67,42.56 25.4,43.83 25.4,48.27 v31.75,48.27 34.29,45.73 36.83,48.27 v39.37,48.27 | IC24.2 155.57,96.53 156.84,97.81 161.93,97.81 161.93,90.82 161.29,90.19 151.13,90.19 148.59,87.64 124.46,87.64 123.19,88.92 DMA8-11.3 114.94,88.92 v114.3,88.28 | v39.37,16.53 40.01,15.89 61.59,15.89 v65.41,19.7 | v69.85,34.3 76.83,34.3 78.11,35.58 v96.52,35.58 | v104.14,82.56 105.41,83.83 v110.49,83.83 | 251.46,148.6 250.19,147.33 IC39.12 | 251.46,148.6 269.24,148.6 270.51,147.33 IC45.12 | 251.46,148.6 225.43,148.6 224.16,147.33 RF08B.23 | 251.46,36.84 250.19,35.58 IC42.12 | 251.46,36.84 267.97,36.84 269.24,35.58 IC43.12 | 251.46,36.84 225.43,36.84 224.16,35.58 RF08A.23
DMA-IN\  (via drill 0.61)
  Top 0.254: v26.67,13.99 22.23,18.43 22.23,33.04 20.32,34.94 20.32,38.12 IC34.1 17.78,48.27 19.68,50.18 19.68,71.77 IC26.1 17.78,76.85 19.05,78.12 19.05,109.23 20.32,110.5 IC13.4
  Bottom 0.254: v26.67,13.99 36.2,13.99 39.37,10.81 71.75,10.81 IC41.12 | IC26.19 21.59,71.14 19.05,73.67 IC26.1
DMA-OUT\  (via drill 0.61)
  Top 0.254: IC28.19 62.87,69.23 62.87,40.02 IC35.19 | v64.77,21.61 v64.77,38.12 | v80.64,18.43 IC41.9 | IC28.1 51.44,71.77 51.44,49.55 52.7,48.27 52.7,41.29 IC35.1
  Bottom 0.254: IC35.1 54.61,40.66 57.15,38.12 IC35.19 v64.77,38.12 | v80.64,18.43 80.01,17.8 68.58,17.8 v64.77,21.61
DONE  (via drill 0.61)  (1 unrouted)
  Top 0.254: v135.25,25.41 135.25,22.24 IC55.2 | v179.07,24.14 181.61,26.69 181.61,61.61 182.25,62.24 182.25,83.2 186.69,87.64 186.69,90.82 184.15,93.36 184.15,113.05 186.69,115.58 | 186.69,115.58 187.96,116.86 IC11.9 | v22.86,36.84 22.86,41.29 22.23,41.92 v22.23,63.52 | v13.97,64.78 14.61,65.42 14.61,90.82 13.97,91.45 13.97,115.58 16.51,118.12 16.51,125.75 20.95,130.19 24.13,130.19 24.13,133.36 21.59,135.9 v21.59,140.35 | v172.09,147.97 186.69,133.36 186.69,115.58 | v156.21,158.76 144.15,158.76 143.51,158.13 143.51,156.86 142.88,156.22 131.44,156.22 130.81,156.86 130.81,158.13 130.18,158.76 v123.83,158.76 | v103.5,165.75 102.23,164.48 86.36,164.48 80.64,170.19 79.38,168.92 79.38,165.11 81.92,162.57 79.38,160.03 62.87,160.03 61.59,161.3 59.05,161.3 58.42,160.67 58.42,159.4 57.15,158.13 SV3.23 | v165.74,185.43 IC49.17
  Bottom 0.254: v135.25,25.41 136.53,26.69 140.34,26.69 142.88,24.14 v179.07,24.14 | v22.86,36.84 33.66,36.84 34.92,38.12 SV1.23 | v22.23,63.52 20.95,64.78 v13.97,64.78 | v21.59,140.35 19.05,142.89 19.05,148.6 55.88,148.6 56.52,149.24 98.42,149.24 99.69,147.97 102.23,147.97 102.87,148.6 120.02,148.6 120.65,147.97 v172.09,147.97 | v165.74,185.43 165.1,184.8 165.1,175.27 168.91,171.46 171.45,171.46 172.09,170.83 172.09,169.56 161.29,158.76 v156.21,158.76 | v123.83,158.76 122.56,160.03 109.22,160.03 v103.5,165.75
DRV01\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v69.85,12.71 73.66,8.91 IC41.4 | v55.88,12.71 51.44,17.16 v51.44,24.14
  Bottom 0.254: v55.88,12.71 v69.85,12.71 | v51.44,24.14 50.16,25.41 RS08.38 | JP1.3 226.06,54.62 222.88,54.62 221.62,53.36 RF08A.38 | JP2.3 226.06,166.38 222.88,166.38 221.62,165.11 RF08B.38
DRV23\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v78.74,44.47 78.11,43.83 78.11,19.7 80.01,17.8 80.01,10.18 81.28,8.91 IC41.7 | JP1.1 233.68,55.9 224.79,47.01 224.79,34.94 224.16,34.3 220.98,34.3 RF08A.22 | JP2.1 233.68,167.65 224.79,158.76 224.79,146.7 224.16,146.06 220.98,146.06 RF08B.22
  Bottom 0.254: v78.74,44.47 47.62,44.47 46.35,45.73 RS08.22
DRVOK\  (via drill 0.61)  (2 unrouted)
  Top 0.254: R2.1 RS08.40 | v46.99,93.36 46.99,97.81 46.35,98.44 46.35,102.25 45.72,102.89 IC21.14 | v53.34,78.75 v53.34,93.36 | v58.42,78.75 57.78,78.12 57.78,43.2 59.05,41.92 59.05,34.94 58.42,34.3 58.42,32.4 57.78,31.77 v57.78,21.61 | RF08A.40 D4.A | RF08B.40 D8.A
  Bottom 0.254: IC21.14 46.35,103.52 47.62,103.52 IC21.13 | v53.34,93.36 v46.99,93.36 | v58.42,78.75 v53.34,78.75 | v57.78,21.61 47.62,21.61 46.35,22.88 RS08.40
DRVSELA\
  Top 0.254: 257.18,31.13 257.18,10.18 261.62,5.73 R3.1 | IC43.22 257.18,31.13 | 257.18,31.13 257.18,53.99 IC44.4
  Bottom 0.254: IC42.22 234.95,33.04 235.59,32.4 247.01,32.4 247.65,31.77 250.19,31.77 251.46,33.04 IC43.22 | D4.C 225.43,66.69 241.94,66.69 243.84,64.78 246.38,64.78 IC44.4
DRVSELB\
  Top 0.254: 258.44,142.89 258.44,123.2 264.16,117.49 R4.1 | IC45.22 258.44,142.89 | 258.44,142.89 258.44,164.48 IC46.4
  Bottom 0.254: IC39.22 234.95,144.79 235.59,144.16 247.01,144.16 247.65,143.52 250.19,143.52 251.46,144.79 IC45.22 | D8.C 225.43,178.45 241.94,178.45 243.84,176.54 246.38,176.54 IC46.4
EIE  (via drill 0.61)  (1 unrouted)
  Top 0.254: IC37.2 194.31,24.14 194.31,8.91 193.68,8.27 187.96,8.27 INTENB.6 | v38.1,3.19 38.1,9.54 35.56,12.08 SV1.3 | v99.69,3.19 102.87,6.36 102.87,19.7 104.14,20.97 v104.14,22.88 | v139.7,24.14 142.88,20.97 142.88,12.08 IC55.9 | v38.1,189.24 22.23,189.24 v19.68,186.7
  Bottom 0.254: IC55.9 146.05,10.18 147.32,8.91 170.18,8.91 171.45,7.63 185.42,7.63 INTENB.6 | v38.1,3.19 v99.69,3.19 | v104.14,22.88 105.41,24.14 v139.7,24.14 | v38.1,189.24 41.91,185.43 IC33.17 | v19.68,186.7 19.05,186.07 19.05,175.91 13.97,170.83 13.97,169.56 24.77,158.76 29.84,158.76 31.11,157.49 SV3.3
ERROR  (via drill 0.61)
  Top 0.254: v147.32,100.34 147.32,36.84 148.59,35.58 148.59,16.53 IC55.10 | v194.31,123.2 194.31,116.22 196.22,114.31 196.22,100.98 IC12.6
  Bottom 0.254: v147.32,100.34 195.58,100.34 196.85,99.08 IC12.6 | v194.31,123.2 191.13,126.38 177.16,126.38 IC7.2
EXAD0\  (via drill 0.61)
  Top 0.254: v4.45,77.48 5.08,76.85 5.08,66.69 7.62,64.15 C35L.34
  Bottom 0.254: v4.45,77.48 19.68,92.72 24.13,92.72 IC20.9
EXAD1\  (via drill 0.61)
  Top 0.254: v8.26,92.72 5.71,90.19 5.71,67.33 6.99,66.06 C35L.36
  Bottom 0.254: v8.26,92.72 8.89,92.72 9.53,93.36 19.68,93.36 IC20.7
EXAD2\  (via drill 0.61)
  Top 0.254: v8.89,94 9.53,93.36 9.53,72.41 8.89,71.77 8.89,70.5 7.62,69.23 C35L.38
  Bottom 0.254: v8.89,94 15.24,94 IC20.5
F.1  (via drill 0.61)  (1 unrouted)
  Top 0.254: SV2.6 35.56,80.03 32.38,80.03 31.75,80.66 31.75,84.47 32.38,85.11 32.38,86.38 31.75,87.01 31.75,101.61 30.48,102.89 IC20.11 30.48,105.42 31.11,106.06 v31.11,111.78 | v194.94,45.73 194.31,46.37 v194.31,81.3 194.31,101.61 v193.68,102.25 | v170.18,111.78 172.09,109.87 v172.09,103.52 | v68.58,173.37 74.93,173.37 77.47,170.83 77.47,165.75 v80.64,162.57 | v97.16,167.02 v100.97,167.02 | v107.31,160.67 v109.22,162.57
  Bottom 0.254: v194.94,45.73 195.58,45.73 IC30.8 | v194.31,81.3 196.85,83.83 FIELD.3 | v31.11,111.78 38.73,111.78 39.37,112.41 39.37,113.68 64.77,113.68 65.41,114.31 88.27,114.31 90.81,111.78 92.08,111.78 92.71,112.41 92.71,113.68 116.84,113.68 120.65,109.87 165.74,109.87 167.64,111.78 v170.18,111.78 | v172.09,103.52 173.35,102.25 v193.68,102.25 | v68.58,173.37 72.39,177.18 72.39,186.07 71.75,186.7 67.31,186.7 64.77,189.24 57.15,189.24 55.88,190.51 IC40.2 | v80.64,162.57 91.44,162.57 92.08,161.94 v97.16,167.02 | v100.97,167.02 v107.31,160.67 | v109.22,162.57 113.03,162.57 114.3,163.84 122.56,163.84 124.46,161.94 130.81,161.94 132.08,160.67 SV4.6
F.2  (via drill 0.61)  (1 unrouted)
  Top 0.254: v24.13,83.2 24.13,101.61 25.4,102.89 IC20.13 | v57.78,81.93 57.78,82.56 56.52,83.83 55.24,83.83 55.24,77.48 55.88,76.85 55.88,75.58 55.24,74.95 52.07,74.95 v52.07,78.75 | v85.09,79.39 86.36,78.12 v86.36,76.22 | v113.03,72.41 v111.12,74.31 | v127.64,71.14 127,70.5 v127,63.52 | v196.85,64.78 201.29,69.23 v201.29,78.12 | v48.26,175.27 48.26,177.81 49.53,179.08 52.07,179.08 55.88,182.89 52.07,186.7 49.53,186.7 48.9,187.34 48.9,191.15 49.53,191.78 54.61,191.78 59.69,196.86 78.11,196.86 v79.38,195.59 | v90.81,196.23 96.52,190.51 v96.52,185.43 | v93.98,179.08 v95.25,177.81 | v93.98,176.54 93.98,172.73 v98.42,168.29
  Bottom 0.254: v24.13,83.2 27.3,80.03 33.66,80.03 34.92,81.3 SV2.4 36.2,81.3 36.83,81.93 55.88,81.93 56.52,81.3 57.15,81.3 v57.78,81.93 | 210.19,77.48 210.19,87.64 200.66,87.64 199.39,86.38 FIELD.2 | 210.19,77.48 210.19,42.56 IC30.11 | v52.07,78.75 53.34,80.03 78.11,80.03 78.74,79.39 80.01,79.39 80.64,78.75 84.45,78.75 v85.09,79.39 | v86.36,76.22 87,75.58 102.23,75.58 103.5,74.31 v111.12,74.31 | v113.03,72.41 124.46,72.41 125.73,71.14 v127.64,71.14 | v127,63.52 168.28,63.52 169.54,64.78 v196.85,64.78 | v201.29,78.12 201.93,77.48 210.19,77.48 | v79.38,195.59 90.17,195.59 v90.81,196.23 | v96.52,185.43 93.98,182.89 v93.98,179.08 | v95.25,177.81 v93.98,176.54 | v98.42,168.29 109.86,156.86 124.46,156.86 126.36,158.76 127.64,158.76 128.91,160.03 SV4.4 | v48.26,175.27 IC33.11
F.3  (via drill 0.61)  (1 unrouted)
  Top 0.254: SV2.2 35.56,97.17 v33.66,99.08 v33.66,125.11 | v90.81,121.3 v88.9,123.2 | v158.75,121.94 161.29,121.94 161.29,125.75 v162.56,127.02 | v193.68,127.02 194.31,127.65 194.31,131.46 198.75,135.9 201.29,135.9 201.29,79.39 FIELD.6 | v46.35,180.35 v46.35,186.7 | v66.67,171.46 71.75,171.46 76.83,166.38 76.83,163.84 v79.38,161.3 | v105.41,157.49 106.05,156.86 120.02,156.86 123.19,160.03 SV4.2
  Bottom 0.254: v33.66,99.08 25.4,99.08 IC20.15 | FIELD.6 199.39,76.22 200.66,74.95 207.01,74.95 209.55,72.41 209.55,43.83 206.38,43.83 IC30.13 | v33.66,125.11 34.92,126.38 59.05,126.38 62.87,122.57 88.27,122.57 v88.9,123.2 | v90.81,121.3 91.44,121.94 v158.75,121.94 | v193.68,127.02 v162.56,127.02 | v46.35,186.7 41.91,186.7 38.1,190.51 IC33.2 | v46.35,180.35 48.26,180.35 49.53,179.08 52.07,179.08 57.15,174 59.69,174 62.23,171.46 v66.67,171.46 | v79.38,161.3 80.01,160.67 102.23,160.67 v105.41,157.49
GND  (via drill 0.61)  (3 unrouted)
  Top 0.254: IC34.10 17.14,17.16 17.14,16.53 15.88,15.26 10.16,15.26 C35L.1 C35L.3 C35L.5 C35L.7 C35L.9 C35L.11 C35L.13 C35L.15 C35L.17 C35L.19 C35L.21 C35L.23 C35L.25 C35L.27 C35L.29 C35L.31 C35L.33 C35L.35 C35L.37 C35L.39 | C35.2 54.61,43.83 53.98,44.47 53.98,50.18 IC28.10 | SV2.26 v35.56,50.81 | IC21.8 58.42,95.27 54.61,91.45 C28.2 | 92.71,112.41 93.34,111.78 IC16.1 93.98,115.58 96.52,118.12 IC16.15 | 92.71,112.41 92.08,113.05 C16.2 | 92.71,112.41 92.71,99.71 91.44,98.44 C33.2 | IC13.2 IC20.17 | IC14.2 IC14.13 | C42.2 138.43,62.88 137.79,63.52 137.79,73.04 137.16,73.67 DAR8-11.8 135.25,78.12 135.25,84.47 DAR8-11.4 139.06,88.28 139.06,96.53 C27.2 138.43,97.17 140.34,99.08 140.34,111.14 IC17.8 | C24.2 153.03,101.61 149.22,105.42 146.69,105.42 146.69,113.05 C18.2 | IC31.10 153.67,40.66 C38.2 | DAR4-7.4 135.25,50.18 135.25,43.83 DAR4-7.8 137.16,27.32 138.43,26.05 C40.2 | C8.2 123.83,96.53 123.83,88.28 DMA8-11.4 120.02,84.47 120.02,78.12 DMA8-11.8 122.56,75.58 122.56,62.24 C39.2 | DMA0-3.4 120.02,19.7 120.02,26.05 121.92,27.96 C46.2 | D36L.1 D36L.3 D36L.5 D36L.7 D36L.9 D36L.11 D36L.13 D36L.15 D36L.17 D36L.19 D36L.21 D36L.23 D36L.25 D36L.27 D36L.29 D36L.31 D36L.33 D36L.35 D36L.37 D36L.39 | D35L.1 D35L.3 D35L.5 D35L.7 D35L.9 D35L.11 D35L.13 D35L.15 D35L.17 D35L.19 D35L.21 D35L.23 D35L.25 D35L.27 D35L.29 D35L.31 D35L.33 D35L.35 D35L.37 D35L.39 | RS08.39 43.18,23.51 44.45,24.78 44.45,31.13 43.18,32.4 RS08.31 | 62.87,26.05 62.87,24.78 IC35.13 62.87,20.97 62.87,16.53 59.05,12.71 | IC35.15 62.87,26.05 | 62.87,26.05 62.87,31.13 IC35.17 | 59.05,12.71 54.61,17.16 54.61,17.8 IC35.10
  Top 0.254: 59.05,12.71 62.87,8.91 C41.2 | J14.2 J13.2 J12.2 J11.2 J10.2 J9.2 J8.2 | IC24.10 153.67,74.95 C31.2 | D34L.39 D34L.37 D34L.35 D34L.33 D34L.31 D34L.29 D34L.27 D34L.25 D34L.23 D34L.21 D34L.19 D34L.17 D34L.15 D34L.13 D34L.11 D34L.9 D34L.7 D34L.5 D34L.3 D34L.1 172.72,22.24 173.99,20.97 173.99,13.35 172.72,12.08 C43.2 | 161.93,14.62 161.93,15.89 | 161.93,15.89 IC38.15 | IC38.13 161.93,14.62 | 161.93,15.89 161.93,20.97 IC38.17 | 161.93,14.62 161.93,9.54 IC38.11 | v185.42,99.08 186.69,97.81 186.69,92.09 187.96,90.82 IC19.7 | C36L.39 C36L.37 C36L.35 C36L.33 C36L.31 C36L.29 C36L.27 C36L.25 C36L.23 C36L.21 C36L.19 C36L.17 C36L.15 C36L.13 C36L.11 C36L.9 C36L.7 C36L.5 C36L.3 C36L.1 190.5,21.61 193.04,19.07 INTENB.9 189.23,13.99 | 189.23,13.99 INTENB.5 | 189.23,13.99 INTENB.8 | C37.2 199.39,33.67 197.49,35.58 197.49,37.48 IC30.10 | FIELD.8 196.22,73.04 196.22,76.85 FIELD.5 197.49,79.39 197.49,80.66 FIELD.4 200.03,83.2 200.03,91.45 C44.2 199.39,95.27 IC12.7 200.03,98.44 200.03,114.31 C12.2 199.39,114.95 200.66,116.22 200.66,129.55 IC8.1 199.39,133.36 C47.2 | IC7.8 190.5,123.2 191.77,121.94 191.77,114.31 190.5,113.05 IC11.7 | 173.35,135.27 175.26,133.36 IC7.15 | 173.35,135.27 173.35,138.44 C45.- | C11.2 172.72,113.68 170.18,116.22 C7.2 170.18,126.38 171.45,127.65 171.45,133.36 173.35,135.27 | IC9.12 124.46,130.82 123.19,129.55 123.19,127.02 121.92,125.75 IC9.2 | C17.2 119.38,113.68 116.84,116.22 C9.2 116.84,126.38 118.11,127.65 118.11,136.54 116.84,137.81 C5.2 | IC10.12 152.4,130.82 151.13,129.55 151.13,127.65 149.86,126.38 IC10.2 | C6.2 144.78,137.81 144.15,137.17 144.15,132.09 143.51,131.46 143.51,127.65 144.78,126.38 C10.2
  Top 0.254: IC4.7 107.31,136.54 108.58,136.54 IC4.8 | IC3.7 79.38,136.54 80.64,136.54 IC3.8 | IC2.7 51.44,136.54 52.7,136.54 IC2.8 | IC17.15 127.64,122.57 130.81,122.57 130.81,125.75 131.44,126.38 134.62,126.38 IC9.7 | G1.- 234.31,81.93 234.31,83.2 G1.-@1 | G2.-@1 262.25,83.2 262.25,81.93 G2.- 262.25,80.66 262.25,75.58 IC44.7 249.56,62.88 249.56,46.37 IC42.16 | RF08A.31 223.52,46.37 222.25,47.64 222.25,53.99 223.52,55.26 RF08A.39 | RF08B.31 223.52,158.13 222.25,159.4 222.25,165.75 223.52,167.02 RF08B.39 | G4.-@1 262.25,194.96 262.25,193.69 G4.- 253.37,183.53 253.37,178.45 IC46.7 251.46,176.54 | G3.-@1 234.31,194.96 234.31,193.69 G3.- 251.46,176.54 | 251.46,176.54 250.19,175.27 250.19,158.76 IC39.16 | 154.94,162.57 SV4.26 SV4.25 | 154.94,162.57 v153.03,164.48 | v151.76,165.75 IC48.10 | 154.94,162.57 IC49.10 | IC48.19 153.67,190.51 151.13,193.05 IC48.1 146.05,193.05 140.97,198.13 101.6,198.13 97.79,194.32 | IC49.19 166.37,190.51 163.83,193.05 IC49.1 168.91,186.7 176.53,186.7 177.16,187.34 v198.12,187.34 | IC33.1 v39.37,193.05 | v46.99,166.38 43.18,166.38 39.37,170.19 IC33.10 | IC56.10 v94.61,167.02 95.89,165.75 100.97,165.75 105.41,170.19 IC47.10 | v96.52,175.27 96.52,177.81 97.79,179.08 100.33,179.08 100.97,179.72 100.97,188.61 IC56.19 | v104.14,195.59 102.87,194.32 97.79,194.32 | v97.16,194.32 97.79,194.32 | v30.48,180.99 30.48,179.72 29.21,178.45 29.21,175.91 v27.94,174.64
  Bottom 0.254: C35L.17 C34.2 | SV2.26 SV2.25 32.38,53.36 31.75,52.72 27.3,52.72 26.67,52.09 20.32,52.09 19.05,50.81 IC26.10 C35L.23 | J2.2 5.71,50.81 6.99,52.09 8.26,52.09 9.53,53.36 C35L.25 | v35.56,50.81 36.2,50.18 40.01,50.18 40.64,49.55 46.35,49.55 46.99,50.18 51.44,50.18 52.07,50.81 IC28.10 | C22.2 59.69,97.81 IC21.8 56.52,98.44 38.1,98.44 C21.2 30.48,97.81 IC20.10 | IC25.8 99.69,71.77 95.89,71.77 IC25.5 92.08,71.77 83.19,71.77 80.01,74.95 | 80.01,74.95 56.52,74.95 55.24,76.22 C28.2 | 80.01,74.95 C25.2 | IC22.7 85.09,97.81 C33.2 | IC16.8 109.86,109.87 95.89,109.87 IC16.1 93.34,111.14 84.45,111.14 IC15.7 81.92,113.68 74.3,113.68 | IC17.15 121.92,116.86 99.06,116.86 IC16.15 | IC20.10 30.48,95.27 26.04,90.82 24.77,90.82 19.68,85.74 19.05,85.74 C26.2 2.54,76.22 2.54,74.95 3.81,73.67 6.99,73.67 9.53,71.14 C35L.39 | C13.2 10.79,113.05 11.43,112.41 12.06,112.41 IC13.1 13.34,111.14 14.61,111.14 IC13.2 17.14,109.87 26.04,109.87 IC13.7 | 6.35,98.44 10.16,102.25 13.34,102.25 IC20.17 | 6.35,98.44 5.71,97.81 C20.2 | 74.3,113.68 66.04,113.68 C15.2 57.15,113.05 IC14.7 53.98,109.87 46.35,109.87 | 74.3,113.68 IC15.4 | IC13.7 29.21,113.05 C14.2 | 46.35,109.87 45.09,109.87 IC14.2 42.55,111.14 41.27,111.14 IC14.1 40.64,110.5 29.21,110.5 IC13.7 | 46.35,109.87 IC14.4 | 6.35,98.44 28.57,98.44 IC20.10 | IC17.8 140.34,112.41 146.05,112.41 146.69,113.05 C18.2 147.96,113.05 148.59,113.68 172.72,113.68 | IC31.10 151.13,41.92 149.86,40.66 139.7,40.66 138.43,41.92 DAR4-7.8 135.89,41.92 134.62,40.66 125.09,40.66 123.83,41.92 DMA4-7.8 120.65,41.92 119.38,43.2 D36L.17 | D36L.5 C46.2 | DMA4-7.4 120.65,52.09 119.38,53.36 D36L.25
  Bottom 0.254: C39.2 122.56,62.24 121.28,63.52 D36L.33 | C27.2 137.79,96.53 136.53,97.81 126.36,97.81 125.09,96.53 C8.2 | 80.01,23.51 79.38,22.88 D35L.1 | 80.01,23.51 80.64,24.14 C36.2 | 80.01,23.51 82.55,20.97 89.53,20.97 IC36.4 92.08,22.24 93.34,22.24 IC36.5 95.89,20.97 99.69,20.97 IC36.8 102.23,22.24 102.87,22.24 103.5,21.61 112.39,21.61 113.67,22.88 D36L.1 | D35L.31 79.38,60.98 80.64,59.7 C29.2 81.28,60.34 92.08,60.34 IC29.5 95.89,56.53 99.69,56.53 IC29.8 | D35L.19 79.38,45.73 80.64,44.47 C32.2 81.28,45.1 92.08,45.1 | 92.08,45.1 IC32.5 | 92.08,45.1 99.69,45.1 IC32.8 | DMA0-3.8 IC23.7 107.31,5.73 98.42,5.73 IC23.2 94.61,9.54 91.44,9.54 C23.2 85.09,8.91 IC41.8 81.92,9.54 63.5,9.54 C41.2 | RS08.31 43.81,33.04 45.09,34.3 54.61,34.3 55.88,33.04 IC35.17 | D35L.5 73.03,27.96 71.75,26.69 66.67,26.69 65.41,27.96 IC35.15 | D34L.17 J6.2 | C31.2 154.31,67.33 155.57,68.59 168.28,68.59 169.54,67.33 170.81,67.33 172.09,68.59 D34L.37 | D34L.13 J8.2 | IC55.7 138.43,7.63 139.7,6.36 149.86,6.36 151.13,7.63 IC38.10 IC38.11 | IC38.13 161.29,12.71 161.93,12.08 172.72,12.08 C43.2 173.35,11.45 173.99,12.08 180.97,12.08 INTENB.4 183.51,9.54 184.78,9.54 INTENB.5 | IC19.7 190.5,91.45 C44.2 | v185.42,99.08 C19.2 | C36L.21 IC30.6 | FIELD.9 FIELD.8 C36L.39 | C36L.33 C30.2 | INTENB.8 195.58,7.63 IC37.10 | INTENB.9 IC37.6 | C36L.13 IC30.10 | C12.2 198.75,114.31 197.49,113.05 191.77,113.05 IC11.7 188.59,113.68 172.72,113.68 | IC6.8 167,139.08 171.45,139.08 C45.- | IC18.7 166.37,113.05 C11.2 172.72,113.68 | IC7.1 171.45,125.75 C7.2 163.83,125.75 IC10.7 160.66,126.38 147.96,126.38 | IC17.1 120.65,113.05 C17.2
  Bottom 0.254: C9.2 116.84,126.38 120.02,126.38 IC9.2 123.83,126.38 132.72,126.38 IC9.7 135.89,125.75 C10.2 144.78,126.38 147.96,126.38 | IC5.7 135.25,137.81 144.78,137.81 C6.2 | 147.96,126.38 IC10.2 | C5.2 116.2,138.44 115.57,137.81 109.86,137.81 IC4.8 | IC3.8 81.92,137.81 87.63,137.81 88.27,138.44 C4.2 88.9,139.08 104.78,139.08 IC4.7 | IC2.8 53.98,137.81 59.69,137.81 60.33,138.44 C3.2 60.96,139.08 76.83,139.08 IC3.7 | C1.2 5.71,138.44 6.35,139.08 20.95,139.08 IC1.7 23.5,136.54 24.77,136.54 IC1.8 26.04,137.81 31.75,137.81 32.38,138.44 C2.2 33.02,139.08 48.9,139.08 IC2.7 | G1.- 250.19,66.06 IC44.7 | IC43.16 269.24,45.73 267.97,44.47 251.46,44.47 250.19,45.73 IC42.16 236.22,45.73 234.95,47.01 225.43,47.01 224.16,45.73 RF08A.31 | IC45.16 270.51,157.49 269.24,156.22 251.46,156.22 250.19,157.49 IC39.16 236.22,157.49 234.95,158.76 225.43,158.76 224.16,157.49 RF08B.31 | v153.03,164.48 v151.76,165.75 | IC49.1 158.75,193.05 156.21,190.51 IC48.19 | IC40.19 57.15,190.51 54.61,193.05 IC40.1 49.53,193.05 46.99,190.51 IC33.19 41.91,190.51 v39.37,193.05 | v46.99,166.38 IC40.10 57.15,163.84 83.19,163.84 84.45,165.11 92.71,165.11 v94.61,167.02 | IC47.19 113.03,190.51 109.22,186.7 105.41,186.7 104.14,187.97 104.14,191.78 105.41,193.05 IC47.1 v104.14,195.59 | IC56.19 100.97,192.42 100.97,193.69 100.33,194.32 v97.16,194.32 95.25,194.32 93.98,193.05 IC56.1 | IC56.10 v96.52,175.27 | v30.48,180.99 29.21,182.26 29.21,193.69 29.84,194.32 31.11,194.32 32.38,193.05 IC33.1 | v27.94,174.64 31.11,171.46 33.02,171.46 34.29,170.19 IC33.10 | v198.12,187.34 199.39,186.07 199.39,184.8 172.09,157.49 SV4.25
INT_RQ\  (via drill 0.61)
  Top 0.254: IC55.3 135.25,15.89 135.25,12.08 IC55.6 | v149.22,55.9 149.22,12.08 IC55.8
  Bottom 0.254: IC55.6 138.43,10.18 140.97,7.63 IC55.8 | v149.22,55.9 153.67,55.9 156.21,58.44 D34L.30
IOS\  (via drill 0.61)
  Top 0.254: v111.76,131.46 111.76,128.92 90.81,128.92 82.55,120.67 82.55,109.23 78.74,105.42 IC22.10 | v186.69,135.9 189.23,133.36 v189.23,99.08 | v169.54,92.09 168.91,91.45 168.91,57.8 170.18,56.53 D34L.28
  Bottom 0.254: v111.76,131.46 114.94,134.63 157.48,134.63 158.12,135.27 186.06,135.27 v186.69,135.9 | v189.23,99.08 189.23,92.09 v169.54,92.09
MEMSUPPLY  (1 unrouted)
  Top 0.508: IC45.32 255.91,118.76 255.91,118.12 254.63,116.86 R4.2 D6.C 233.04,117.49 233.04,118.76 IC39.32 236.22,121.94 D5.C | IC43.32 254,7.63 254,7 252.09,5.09 R3.2 D1.C 233.04,5.73 233.04,7 IC42.32 236.22,10.18 D2.C
  Bottom 0.508: D5.C 238.76,162.57 IC46.14 246.38,162.57 247.65,161.3 262.89,161.3 D7.C | D2.C 238.76,50.81 IC44.14 246.38,50.81 247.65,49.55 262.89,49.55 D3.C
MYDEV\
  Top 0.254: 90.17,55.9 91.44,57.16 IC29.4 | 90.17,55.9 90.17,45.73 91.44,44.47 IC32.4 | 90.17,55.9 90.17,71.14 91.44,72.41 IC25.4
  Bottom 0.254: IC32.4 99.06,35.58 PAD1.1
N$1
  Top 0.254: IC36.9 PAD8.1
N$2  (via drill 0.61)
  Top 0.254: v179.07,129.55 181.61,127.02 181.61,121.94 182.88,120.67 IC11.11
  Bottom 0.254: v179.07,129.55 165.1,129.55 IC10.8
N$3  (via drill 0.61)
  Top 0.254: v125.73,49.55 126.36,48.91 126.36,40.66 125.09,39.38 125.09,31.77 125.73,31.13 125.73,30.5 125.09,29.86 125.09,18.43 DMA0-3.5
  Bottom 0.254: v125.73,49.55 DMA4-7.12
N$4  (via drill 0.61)
  Top 0.254: SW1.1 8.26,123.84 9.53,123.84 SW1.2 10.79,123.84 12.06,123.84 SW1.3 13.34,123.84 14.61,123.84 SW1.4 | 19.05,123.84 18.41,123.84 SW1.5 | 19.05,123.84 19.68,123.84 SW1.6 20.95,123.84 22.23,123.84 SW1.7 | v49.53,115.58 49.53,110.5 46.99,107.97 46.99,99.08 48.26,97.81 IC21.4 | v20.32,114.31 19.05,115.58 19.05,123.84
  Bottom 0.254: SW1.5 17.14,123.84 15.88,123.84 SW1.4 | SW1.8 24.77,123.84 23.5,123.84 SW1.7 | v49.53,115.58 26.67,115.58 25.4,114.31 v20.32,114.31
N$5
  Top 0.254: IC36.15 PAD2.1
N$6
  Top 0.254: IC36.14 PAD3.1
N$7
  Top 0.254: IC36.13 PAD4.1
N$8
  Top 0.254: IC36.12 PAD5.1
N$9
  Top 0.254: IC36.11 PAD6.1
N$10
  Top 0.254: IC36.10 PAD7.1
N$11  (via drill 0.61)
  Top 0.254: v104.14,27.96 PAD9.1
  Bottom 0.254: IC36.7 v104.14,27.96
N$12  (via drill 0.61)
  Top 0.254: DAR4-7.14 142.88,56.53 142.88,60.34 143.51,60.98 144.78,60.98 144.78,73.67 142.88,75.58 142.88,87.01 DAR8-11.14 146.69,90.82 146.69,98.44 146.05,99.08 v146.05,116.86
  Bottom 0.254: v146.05,116.86 162.56,116.86 IC18.8
N$13  (via drill 0.61)
  Top 0.254: v132.72,50.81 132.08,51.45 132.08,81.3 DMA8-11.12
  Bottom 0.254: v132.72,50.81 124.46,50.81 123.19,49.55 DMA4-7.5
N$14  (via drill 0.61)
  Top 0.254: v31.11,114.31 31.11,114.95 27.94,118.12 IC13.8 | v81.28,115.58 IC15.6
  Bottom 0.254: v31.11,114.31 50.8,114.31 | 50.8,114.31 IC14.8 | v81.28,115.58 80.64,114.95 53.98,114.95 53.34,114.31 50.8,114.31
N$15  (via drill 0.61)
  Top 0.254: v41.91,149.88 41.91,142.25 45.72,138.44 IC2.5 | v120.65,149.24 120.65,140.35 121.92,139.08 IC5.2
  Bottom 0.254: v41.91,149.88 99.06,149.88 100.33,148.6 101.6,148.6 102.23,149.24 v120.65,149.24
N$16  (via drill 0.61)
  Top 0.254: v133.99,71.14 133.99,50.81 133.35,50.18 133.35,8.91 128.27,8.91 126.36,10.81 126.36,15.26 DMA0-3.12 | v125.09,73.04 125.09,83.2 v124.46,83.83
  Bottom 0.254: v133.99,71.14 132.08,73.04 v125.09,73.04 | v124.46,83.83 125.73,85.11 132.72,85.11 133.99,83.83 DAR8-11.5
N$17
  Top 0.254: SW2.1 36.2,123.84 37.47,123.84 SW2.2 38.73,123.84 40.01,123.84 SW2.3 41.27,123.84 42.55,123.84 SW2.4 43.81,123.84 45.09,123.84 SW2.5 46.35,123.84 47.62,123.84 SW2.6 | IC21.5 50.8,97.81 52.07,99.08 52.07,121.94 50.8,123.2 SW2.7 51.44,123.84 52.7,123.84 SW2.8
  Bottom 0.254: SW2.6 48.9,123.84 50.16,123.84 SW2.7
N$18
  Top 0.254: IC44.3 250.82,57.8 250.82,59.07 IC44.5 252.09,61.61 252.09,62.88 IC44.6
N$19
  Top 0.254: IC21.6 53.34,97.81 54.61,99.08 54.61,120.67 57.78,123.84 62.87,123.84 SW3.1 | SW3.2 66.67,123.84 67.94,123.84 SW3.3 69.22,123.84 70.48,123.84 SW3.4 71.75,123.84 73.03,123.84 SW3.5 74.3,123.84 75.56,123.84 SW3.6 | SW3.8 80.64,123.84 79.38,123.84 SW3.7
  Bottom 0.254: SW3.2 65.41,123.84 64.14,123.84 SW3.1 | SW3.7 78.11,123.84 76.83,123.84 SW3.6
N$20  (via drill 0.61)
  Top 0.254: v57.15,117.49 57.15,99.08 55.88,97.81 IC21.7 | SW4.1 92.08,123.84 93.34,123.84 SW4.2 94.61,123.84 95.89,123.84 SW4.3 97.16,123.84 98.42,123.84 SW4.4 99.69,123.84 100.97,123.84 SW4.5 102.23,123.84 103.5,123.84 SW4.6 104.78,123.84 106.05,123.84 SW4.7 107.31,123.84 108.58,123.84 SW4.8
  Bottom 0.254: v57.15,117.49 61.59,121.94 88.9,121.94 SW4.1
N$21  (via drill 0.61)
  Top 0.254: v100.33,149.88 73.66,149.88 69.85,146.06 69.85,142.25 73.66,138.44 IC3.5 | v122.56,149.24 125.73,146.06 125.73,139.71 127,138.44 IC5.4
  Bottom 0.254: v100.33,149.88 100.97,150.51 121.28,150.51 v122.56,149.24
N$22  (via drill 0.61)
  Top 0.254: 127.64,52.72 127.64,41.29 129.54,39.38 129.54,26.69 128.27,26.69 127.64,26.05 127.64,22.24 DMA0-3.14 | 127.64,52.72 DMA4-7.14 | 127.64,52.72 127.64,60.98 128.91,60.98 129.54,61.61 129.54,73.04 127.64,74.95 127.64,87.01 DMA8-11.14 127,91.45 127,99.08 v133.99,106.06 | v158.12,106.7 158.12,107.33 IC18.6
  Bottom 0.254: v158.12,106.7 157.48,106.06 v133.99,106.06
N$23
  Bottom 0.254: IC1.5 19.68,135.27 79.38,135.27 80.01,135.9 80.01,139.71 118.11,139.71 119.38,138.44 IC5.1
N$24
  Bottom 0.254: IC4.5 103.5,135.27 127.64,135.27 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v141.6,58.44 141.6,47.01 139.7,47.01 DAR4-7.5 | v148.59,58.44 147.96,59.07 147.96,81.93 v148.59,82.56
  Bottom 0.254: v141.6,58.44 v148.59,58.44 | v148.59,82.56 147.32,83.83 DAR8-11.12
N$26  (via drill 0.61)
  Top 0.254: v103.5,100.98 105.41,102.89 105.41,116.86 106.68,118.12 IC16.11 | IC22.1 v68.58,99.71
  Bottom 0.254: v68.58,99.71 69.85,100.98 v103.5,100.98
N$27  (via drill 0.61)
  Top 0.254: v127.64,106.06 129.54,107.97 IC17.4
  Bottom 0.254: v127.64,106.06 125.09,106.06 124.46,106.7 123.83,106.06 93.34,106.06 92.71,105.42 88.9,105.42 88.27,106.06 78.11,106.06 IC22.11
N$28
  Top 0.254: IC19.1 172.72,90.19 168.91,94 168.91,139.08 172.09,142.25 176.53,142.25 176.53,138.44 181.61,133.36 181.61,128.28 182.88,127.02 IC7.5
N$29
  Top 0.254: RA.2 RB.1 208.28,122.57 209.55,123.84 209.55,125.75 IC8.7
N$30
  Top 0.254: IC12.2 197.49,109.87 197.49,111.14 IC12.1 198.12,117.49 200.03,119.39 200.03,125.11 IC8.3
  Bottom 0.254: IC8.3 196.22,128.92 195.58,128.92 RL.2
N$31