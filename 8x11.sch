# EAGLE board 8x11 (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$31 (continued)
  Top 0.254: IC18.11 157.48,120.67 156.21,121.94 156.21,129.55 157.48,130.82 IC10.10
N$32
  Top 0.254: RB.2 197.49,121.94 196.22,123.2 196.22,127.65 IC8.2
  Bottom 0.254: 200.03,129.55 201.93,129.55 204.47,127.02 IC8.6 | IC8.2 200.03,129.55 | 200.03,129.55 204.47,134 C47.1
N$33
  Top 0.254: IC19.11 180.34,97.81 181.61,99.08 181.61,115.58 184.15,118.12 184.15,129.55 182.88,130.82 IC7.12
N$34
  Top 0.254: IC8.5 C48.2
N$35
  Top 0.254: IC44.1 252.09,51.45 252.09,52.72 IC44.2
  Bottom 0.254: JP1.2 233.68,54.62 248.92,54.62 250.19,53.36 IC44.2
N$36
  Top 0.254: D7.A G4.+@1 267.33,173.37 267.33,174.64 G4.+@2 | G4.+ 258.44,173.37 258.44,174.64 G4.+@3
  Bottom 0.254: G4.+ 260.35,174 261.62,174 G4.+@4 264.16,174 265.43,174 G4.+@1
N$37
  Top 0.254: IC12.9 205.1,99.71 205.1,100.98 IC12.10 205.1,102.25 205.1,103.52 IC12.11
N$38
  Top 0.254: IC46.3 250.82,169.56 250.82,170.83 IC46.5 252.09,173.37 252.09,174.64 IC46.6
N$39
  Top 0.254: IC46.1 252.09,163.21 252.09,164.48 IC46.2
  Bottom 0.254: JP2.2 233.68,166.38 248.92,166.38 250.19,165.11 IC46.2
N$40
  Bottom 0.254: IC12.5 199.39,101.61 204.47,96.53 IC12.8
N$41
  Top 0.254: D5.A G3.+@1 239.4,173.37 239.4,174.64 G3.+@2 | G3.+ 230.5,173.37 230.5,174.64 G3.+@3
  Bottom 0.254: G3.+ 232.41,174 233.68,174 G3.+@4 236.22,174 237.49,174 G3.+@1
N$42
  Top 0.254: RN3.2 F.3.A
N$43
  Top 0.254: RN3.3 18.41,190.51 20.95,193.05 F.2.A
N$44
  Top 0.254: RN3.4 19.68,187.97 23.5,191.78 26.04,191.78 27.3,193.05 F.1.A
N$45
  Top 0.254: RN4.2 DEA8.A
N$46
  Top 0.254: RN2.2 DEA2.A
N$47
  Top 0.254: RN2.3 184.78,190.51 187.32,193.05 DEA1.A
N$48
  Top 0.254: RN1.2 DEA5.A
N$49
  Top 0.254: RN1.3 126.36,190.51 128.91,193.05 DEA4.A
N$50
  Top 0.254: RN1.4 125.09,187.97 128.91,191.78 137.79,191.78 139.06,193.05 DEA3.A
N$51
  Top 0.254: RN2.4 189.87,187.97 194.94,193.05 DEA0.A
N$52
  Top 0.254: RN2.5 DMA09.A
N$53
  Bottom 0.254: SW1.16 9.53,130.19 13.34,130.19 13.97,130.82 13.97,136.54 14.61,136.54 IC1.4
N$54
  Top 0.254: SW1.15 10.16,133.36 12.7,135.9 IC1.3
N$55
  Bottom 0.254: SW1.14 12.7,133.36 10.16,135.9 IC1.2
N$56
  Top 0.254: IC1.1 7.62,135.9 8.89,134.63 8.89,130.82 9.53,130.19 14.61,130.19 14.61,131.46 SW1.13
N$57
  Top 0.254: SW1.11 17.78,129.55 6.35,129.55 6.35,138.44 IC1.14
N$58
  Top 0.254: SW1.10 19.05,135.9 19.05,139.71 15.24,143.52 IC1.13
N$59
  Top 0.254: SW1.9 25.4,133.36 24.13,134.63 24.13,139.08 20.32,142.89 17.78,142.89 IC1.12
N$60
  Top 0.254: SW1.12 13.97,135.9 13.97,146.06 13.34,146.7 10.16,146.7 IC1.15
N$61
  Top 0.254: SW2.16 35.56,133.36 36.83,134.63 36.83,138.44 37.47,139.08 42.55,139.08 42.55,137.81 IC2.4
N$62
  Top 0.254: SW2.15 38.1,133.36 40.64,135.9 IC2.3
N$63
  Top 0.254: SW2.14 38.73,130.19 36.83,130.19 36.83,133.36 38.1,134.63 IC2.2
N$64
  Top 0.254: IC2.1 35.56,135.9 34.29,134.63 34.29,130.82 35.56,129.55 42.55,129.55 42.55,131.46 SW2.13
N$65
  Top 0.254: SW2.11 44.45,135.9 44.45,138.44 40.64,142.25 IC2.14
N$66
  Top 0.254: SW2.10 46.99,135.9 46.99,139.71 43.18,143.52 IC2.13
N$67
  Top 0.254: SW2.9 49.53,135.9 49.53,139.71 45.72,143.52 IC2.12
N$68
  Top 0.254: SW3.16 63.5,133.36 64.14,134 64.14,135.27 64.77,135.9 64.77,138.44 65.41,139.08 70.48,139.08 70.48,137.81 IC3.4
N$69
  Top 0.254: SW3.15 66.04,133.36 68.58,135.9 IC3.3
N$70
  Top 0.254: SW3.14 66.67,130.19 64.77,130.19 64.77,134.63 66.04,135.9 IC3.2
N$71
  Top 0.254: IC3.1 63.5,135.9 62.23,134.63 62.23,130.82 63.5,129.55 70.48,129.55 70.48,131.46 SW3.13
N$72
  Top 0.254: SW3.11 72.39,135.9 72.39,138.44 68.58,142.25 IC3.14
N$73
  Top 0.254: SW3.10 74.93,135.9 74.93,139.71 71.12,143.52 IC3.13
N$74
  Top 0.254: SW3.9 77.47,135.9 77.47,139.71 73.66,143.52 IC3.12
N$75
  Top 0.254: SW4.16 93.34,130.19 97.79,130.19 97.79,134.63 99.06,135.9 IC4.4
N$76
  Top 0.254: SW4.15 93.98,133.36 96.52,135.9 IC4.3
N$77
  Bottom 0.254: SW4.14 96.52,133.36 93.98,135.9 IC4.2
N$78
  Bottom 0.254: SW4.13 97.16,130.19 93.34,130.19 92.71,130.82 92.71,135.9 91.44,135.9 IC4.1
N$79
  Top 0.254: SW4.11 104.14,133.36 102.87,134.63 102.87,140.98 100.33,143.52 100.33,146.06 99.69,146.7 96.52,146.7 IC4.14
N$80
  Top 0.254: SW4.10 104.78,130.19 102.87,130.19 102.87,133.36 100.33,135.9 100.33,142.25 99.06,143.52 IC4.13
N$81
  Top 0.254: SW4.9 105.41,135.9 105.41,139.71 101.6,143.52 IC4.12
N$82
  Top 0.254: SW4.12 99.06,129.55 89.53,129.55 89.53,137.17 90.17,137.81 90.17,138.44 93.98,142.25 IC4.15
N$83
  Top 0.254: SW3.12 73.66,130.82 70.48,127.65 62.23,127.65 62.23,129.55 61.59,130.19 61.59,137.17 62.23,137.81 62.23,139.71 66.04,143.52 IC3.15
N$84
  Top 0.254: SW2.12 45.72,130.82 42.55,127.65 33.66,127.65 33.66,137.17 34.29,137.81 34.29,139.71 38.1,143.52 IC2.15
N$85
  Top 0.254: RN2.6 184.78,182.89 187.32,185.43 DMA10.A
N$86
  Top 0.254: RN3.5 DMA00.A
N$87
  Top 0.254: RN3.6 18.41,182.89 20.95,185.43 DMA01.A
N$88
  Top 0.254: RN3.7 22.23,180.35 27.3,185.43 DMA02.A
N$89
  Top 0.254: RN4.3 73.03,190.51 75.56,193.05 DEA7.A
N$90
  Top 0.254: RN4.4 64.77,187.97 66.67,189.88 80.01,189.88 83.19,193.05 DEA6.A
N$91
  Bottom 0.254: DMA03.A RN4.5
N$92
  Top 0.254: RN1.6 128.91,182.89 131.44,185.43 DMA07.A
N$93
  Top 0.254: RN1.5 DMA06.A
N$94  (via drill 0.61)
  Top 0.254: v121.92,184.16 118.11,184.16 117.47,183.53 117.47,182.26 RN1.7 | v124.46,181.62 135.25,181.62 139.06,185.43 DMA08.A
  Bottom 0.254: v121.92,184.16 v124.46,181.62
N$95
  Bottom 0.254: RN2.7 189.87,180.35 194.94,185.43 DMA11.A
N$96
  Top 0.254: RN2.8 DMB09.A
N$97
  Top 0.254: RN2.9 184.78,175.27 187.32,177.81 DMB10.A
N$98
  Top 0.254: RN3.13 22.23,165.11 27.3,170.19 PIE.A
N$99
  Top 0.254: RN3.12 18.41,167.65 20.95,170.19 EIE.A
N$100
  Top 0.254: RN3.11 CIE.A
N$101
  Top 0.254: RN4.6 73.03,182.89 75.56,185.43 DMA04.A
N$102
  Top 0.254: RN4.7 64.77,180.35 66.67,182.26 80.01,182.26 83.19,185.43 DMA05.A
N$103
  Top 0.254: RN4.8 DMB03.A
N$104
  Top 0.254: RN1.8 DMB06.A
N$105
  Top 0.254: RN1.9 128.91,175.27 131.44,177.81 DMB07.A
N$106
  Top 0.254: RN1.10 120.65,172.73 121.92,174 135.25,174 139.06,177.81 DMB08.A
N$107
  Top 0.254: RN2.10 189.87,172.73 194.94,177.81 DMB11.A
N$108
  Top 0.254: RN2.11 WCO.A
N$109
  Top 0.254: RN2.12 184.78,167.65 187.32,170.19 PER.A
N$110
  Top 0.254: RN3.10 22.23,172.73 27.3,177.81 DMB02.A
N$111
  Top 0.254: RN3.9 18.41,175.27 20.95,177.81 DMB01.A
N$112
  Top 0.254: RN3.8 DMB00.A
N$113
  Top 0.254: RN4.11 DRE.A
N$114
  Bottom 0.254: RN4.12 73.03,167.65 75.56,170.19 R/W.A
N$115
  Bottom 0.254: RN4.13 66.04,165.11 67.94,167.02 80.01,167.02 83.19,170.19 DBR.A
N$116  (via drill 0.61)
  Top 0.254: v111.76,166.38 112.39,165.75 114.94,165.75 116.84,163.84 v123.83,163.84 | v128.27,166.38 DRL.A
  Bottom 0.254: v111.76,166.38 113.03,166.38 116.84,170.19 RN1.11 | v123.83,163.84 126.36,166.38 v128.27,166.38
N$117
  Bottom 0.254: RN1.12 121.92,167.65 123.19,168.92 130.18,168.92 131.44,170.19 WLS.A
N$118
  Bottom 0.254: RN1.13 123.83,165.11 126.36,167.65 136.53,167.65 139.06,170.19 NXD.A
N$119
  Top 0.254: RN2.13 189.87,165.11 194.94,170.19 DCF.A
N$120  (via drill 0.61)
  Top 0.254: v166.37,176.54 153.67,176.54 149.86,172.73 IC48.9
  Bottom 0.254: v166.37,176.54 165.74,177.18 165.74,184.16 168.28,186.7 180.97,186.7 182.25,185.43 DMA09.K
N$121
  Top 0.254: IC48.7 152.4,177.81 153.67,179.08 180.97,179.08 182.25,177.81 DMB09.K
N$122
  Bottom 0.254: IC33.18 36.2,194.96 20.32,194.96 18.41,193.05 F.3.K
N$123  (via drill 0.61)
  Top 0.254: v33.02,186.7 20.95,186.7 19.68,185.43 DMA00.K
  Bottom 0.254: v33.02,186.7 38.1,186.7 41.91,182.89 IC33.16
N$124  (via drill 0.61)
  Top 0.254: v36.2,167.65 v38.73,167.65
  Bottom 0.254: v36.2,167.65 22.23,167.65 19.68,170.19 CIE.K | v38.73,167.65 38.73,169.56 41.91,172.73 IC33.12
N$125  (via drill 0.61)
  Top 0.254: v40.01,175.91 40.01,178.45 36.83,181.62 34.29,181.62 33.66,182.26 30.48,182.26 24.77,176.54 23.5,176.54 22.86,177.18 22.86,178.45 22.23,179.08 20.95,179.08 19.68,177.81 DMB00.K
  Bottom 0.254: v40.01,175.91 41.91,177.81 IC33.14
N$126
  Bottom 0.254: DMA01.K 24.77,185.43 32.38,177.81 IC33.7
N$127
  Bottom 0.254: IC33.9 31.11,172.73 26.04,177.81 26.04,181.62 22.86,184.8 22.86,191.15 24.13,192.42 F.2.K
N$128
  Top 0.254: DMB01.K 24.77,177.81 29.84,182.89 IC33.5
N$129  (via drill 0.61)
  Top 0.254: v24.77,180.35 26.04,180.35 29.84,184.16 31.75,184.16 IC33.3
  Bottom 0.254: v24.77,180.35 25.4,179.72 25.4,177.18 24.13,175.91 EIE.K
N$130
  Top 0.254: D3.A G2.+@1 267.33,61.61 267.33,62.88 G2.+@2 | G2.+ 258.44,61.61 258.44,62.88 G2.+@3
  Bottom 0.254: G2.+ 260.35,62.24 261.62,62.24 G2.+@4 264.16,62.24 265.43,62.24 G2.+@1
N$131
  Top 0.254: D2.A G1.+@1 239.4,61.61 239.4,62.88 G1.+@2 | G1.+ 230.5,61.61 230.5,62.88 G1.+@3
  Bottom 0.254: G1.+ 232.41,62.24 233.68,62.24 G1.+@4 236.22,62.24 237.49,62.24 G1.+@1
N$132
  Bottom 0.254: F.1.K 30.48,192.42 33.66,189.24 36.83,189.24 41.91,184.16 46.99,184.16 49.53,186.7 55.88,186.7 57.15,187.97 IC40.18
N$133  (via drill 0.61)
  Top 0.254: v54.61,182.89 53.34,182.89 52.07,181.62 49.53,181.62 v46.35,178.45 | v39.37,174 37.47,175.91 v37.47,179.08
  Bottom 0.254: v46.35,178.45 44.45,176.54 41.91,176.54 v39.37,174 | v37.47,179.08 34.29,179.08 30.48,182.89 DMA02.K | v54.61,182.89 IC40.16
N$134
  Bottom 0.254: DMB02.K 31.11,177.81 32.38,176.54 36.83,176.54 41.91,181.62 53.34,181.62 57.15,177.81 IC40.14
N$135  (via drill 0.61)
  Top 0.254: v33.02,170.19 34.29,168.92 39.37,168.92 43.18,165.11 49.53,165.11 57.15,172.73 IC40.12
  Bottom 0.254: PIE.K v33.02,170.19
N$136
  Bottom 0.254: IC40.5 53.34,182.89 57.15,179.08 69.22,179.08 70.48,177.81 DMB03.K
N$137  (via drill 0.61)
  Top 0.254: v55.88,181.62 52.07,177.81 IC40.7 | v69.22,180.99 v66.67,180.99
  Bottom 0.254: v55.88,181.62 66.04,181.62 v66.67,180.99 | v69.22,180.99 69.22,182.89 71.12,184.8 DMA03.K
N$138
  Top 0.254: IC40.9 52.7,174.64 52.7,177.18 57.15,181.62 56.52,182.26 56.52,188.61 57.15,189.24 59.69,189.24 62.23,191.78 69.22,191.78 70.48,193.05 DEA8.K
N$139
  Top 0.254: IC40.3 53.34,187.97 57.15,191.78 59.69,191.78 62.23,194.32 76.83,194.32 78.11,193.05 DEA7.K
N$140  (via drill 0.61)
  Top 0.254: v81.92,182.89 86.36,182.89 v88.27,184.8
  Bottom 0.254: v81.92,182.89 79.38,185.43 DMA04.K | v88.27,184.8 90.17,186.7 95.25,186.7 96.52,187.97 IC56.18
N$141  (via drill 0.61)
  Top 0.254: v80.64,179.08 79.38,177.81 DMB04.K
  Bottom 0.254: v80.64,179.08 84.45,175.27 88.9,175.27 90.17,176.54 92.71,176.54 IC56.16
N$142
  Bottom 0.254: R/W.K 81.92,170.19 83.19,171.46 87.63,171.46 90.17,174 93.98,174 97.79,177.81 IC56.14
N$143
  Top 0.254: DMB05.K IC56.7
N$144  (via drill 0.61)
  Top 0.254: v81.92,185.43 86.36,189.88 DEA6.K | v85.09,168.92 v85.09,179.72
  Bottom 0.254: v81.92,185.43 85.09,182.26 v85.09,179.72 | v85.09,168.92 92.71,168.92 96.52,172.73 IC56.12
N$145  (via drill 0.61)
  Top 0.254: v80.64,176.54 85.72,181.62 88.9,181.62 90.17,182.89 IC56.5 | v86.36,172.73 DBR.K
  Bottom 0.254: v86.36,172.73 84.45,172.73 v80.64,176.54
N$146
  Top 0.254: IC47.16 118.11,186.7 125.09,186.7 126.36,185.43 DMA06.K
N$147  (via drill 0.61)
  Top 0.254: v128.27,184.16 128.27,186.07 126.36,187.97 v128.91,190.51
  Bottom 0.254: v128.27,184.16 120.65,176.54 118.11,176.54 IC47.12 | v128.91,190.51 131.44,190.51 133.99,193.05 DEA4.K
N$148  (via drill 0.61)
  Top 0.254: IC47.7 v110.49,181.62
  Bottom 0.254: v110.49,181.62 110.49,184.16 113.03,186.7 125.09,186.7 127.64,189.24 132.72,189.24 135.89,186.07 135.89,179.72 134.62,178.45 DMB07.K
N$149
  Top 0.254: IC47.18 118.11,191.78 125.09,191.78 126.36,193.05 DEA5.K
N$150  (via drill 0.61)
  Top 0.254: v116.84,172.73 115.57,171.46 113.03,171.46 111.76,172.73 IC47.9
  Bottom 0.254: v116.84,172.73 118.11,171.46 122.56,171.46 134.62,183.53 DMA07.K
N$151  (via drill 0.61)
  Top 0.254: v116.84,184.16 116.84,182.89 115.57,181.62 113.03,181.62 111.76,182.89 IC47.5 | v127.64,187.97 v136.53,187.97
  Bottom 0.254: v116.84,184.16 120.65,184.16 121.92,185.43 122.56,185.43 123.83,184.16 125.09,184.16 125.73,184.8 125.73,186.07 v127.64,187.97 | v136.53,187.97 137.16,187.34 137.16,173.37 137.79,172.73 135.25,170.19 WLS.K
N$152
  Top 0.254: IC47.14 116.84,177.81 118.11,179.08 125.09,179.08 126.36,177.81 DMB06.K
N$153
  Bottom 0.254: IC47.3 104.78,189.88 104.78,191.15 105.41,191.78 110.49,191.78 116.84,198.13 136.53,198.13 141.6,193.05 DEA3.K
N$154
  Bottom 0.254: DMA08.K 144.78,185.43 146.05,186.7 152.4,186.7 153.67,187.97 IC48.18
N$155
  Bottom 0.254: DMB08.K 142.24,178.45 145.41,181.62 152.4,181.62 153.67,182.89 IC48.16
N$156
  Top 0.254: NXD.K 142.24,170.83 145.41,174 149.86,174 153.67,177.81 IC48.14
N$157  (via drill 0.61)
  Top 0.254: v158.75,184.16 v167,184.16
  Bottom 0.254: v158.75,184.16 153.67,184.16 151.76,182.26 150.5,182.26 149.86,182.89 IC48.5 | v167,184.16 167,178.45 166.37,177.81 167.64,176.54 171.45,176.54 173.35,174.64 173.35,172.1 173.99,171.46 180.97,171.46 182.25,170.19 WCO.K
N$158
  Top 0.254: IC49.12 172.72,172.73 173.99,171.46 188.59,171.46 189.87,170.19 PER.K
N$159
  Bottom 0.254: IC49.14 172.72,177.81 173.99,176.54 188.59,176.54 189.87,177.81 DMB10.K
N$160
  Bottom 0.254: IC48.12 160.02,177.81 160.02,190.51 161.29,191.78 180.97,191.78 182.25,193.05 DEA2.K
N$161
  Bottom 0.254: IC49.16 172.72,182.89 173.99,184.16 188.59,184.16 189.87,185.43 DMA10.K
N$162
  Top 0.254: IC49.18 172.72,187.97 173.99,189.24 186.06,189.24 189.87,193.05 DEA1.K
N$163
  Top 0.254: IC48.15 IC48.3
N$164  (via drill 0.61)
  Top 0.254: IC49.7 v167.64,177.81
  Bottom 0.254: v167.64,177.81 168.91,179.08 191.13,179.08 197.49,185.43 DMA11.K
N$165  (via drill 0.61)
  Top 0.254: v192.41,184.16 184.78,176.54 168.91,176.54 165.1,172.73 IC49.9
  Bottom 0.254: v192.41,184.16 192.41,186.7 198.12,192.42 DEA0.K
N$166
  Top 0.254: IC49.5 167.64,182.89 168.91,184.16 184.78,184.16 187.32,186.7 196.22,186.7 196.85,186.07 196.85,179.72 198.12,178.45 DMB11.K
N$167
  Bottom 0.254: DCF.K 198.12,175.91 200.03,177.81 200.03,193.05 198.75,194.32 186.06,194.32 180.97,189.24 165.1,189.24 163.83,187.97 IC49.3
N$169
  Top 0.254: PAD10.1 DRE.K
N$170
  Top 0.254: DRL.K 127,169.56 129.54,167.02 129.54,166.38 128.27,165.11 PAD11.1
N$171  (via drill 0.61)
  Top 0.254: v88.9,176.54 88.9,175.27 IC56.9
  Bottom 0.254: v88.9,176.54 88.9,178.45 86.36,180.99 DMA05.K
N$172
  Top 0.254: RN4.9 61.59,177.18 61.59,178.45 62.23,179.08 69.22,179.08 69.85,178.45 70.48,179.08 74.3,179.08 75.56,177.81 DMB04.A
N$173
  Top 0.254: RN4.10 64.77,172.73 66.67,174.64 80.01,174.64 83.19,177.81 DMB05.A
N$175
  Top 0.254: IC56.3 92.71,187.97 97.16,183.53 97.16,182.26 IC56.15
NXD  (via drill 0.61)  (1 unrouted)
  Top 0.254: v101.6,3.83 104.14,6.36 IC23.5 | v36.83,5.73 34.29,8.27 34.29,18.43 33.66,19.07 31.75,19.07 31.75,26.05 32.38,26.69 34.29,26.69 34.29,28.59 35.56,29.86 SV1.17 | v189.23,39.38 189.23,16.53 184.15,11.45 v184.15,2.56 | v144.78,186.7 144.78,185.43 146.05,184.16 148.59,184.16 149.22,183.53 149.22,182.26 IC48.6 | v140.97,186.7 137.79,186.7 133.99,182.89 v132.72,182.89 | v129.54,179.72 122.56,179.72 v121.92,180.35 | v93.98,168.92 v93.98,171.46 | v67.94,165.75 64.77,168.92 57.15,168.92 50.8,162.57 50.8,159.4 49.53,158.13 SV3.17
  Bottom 0.254: v36.83,5.73 38.73,3.83 83.82,3.83 84.45,4.46 100.97,4.46 v101.6,3.83 104.14,1.28 182.88,1.28 v184.15,2.56 | v189.23,39.38 199.39,39.38 204.47,44.47 207.65,44.47 207.65,51.45 207.01,52.09 204.47,52.09 203.84,52.72 200.03,52.72 199.39,53.36 IC30.4 | v140.97,186.7 v144.78,186.7 | v129.54,179.72 v132.72,182.89 | v121.92,180.35 120.65,179.08 105.41,179.08 100.33,174 96.52,174 v93.98,171.46 | v93.98,168.92 91.44,166.38 68.58,166.38 v67.94,165.75
NXD\  (via drill 0.61)
  Top 0.254: v176.53,4.46 176.53,1.92 112.39,1.92 IC23.6 | v208.91,8.91 210.19,10.18 210.19,108.6 208.91,109.87 207.65,109.87 207.65,108.6 IC12.12
  Bottom 0.254: v176.53,4.46 177.8,5.73 201.29,5.73 204.47,8.91 v208.91,8.91
PBIT  (via drill 0.61)
  Top 0.254: v87.63,120.67 90.17,120.67 90.81,120.03 92.71,120.03 92.71,120.67 93.34,121.3 97.79,121.3 97.79,115.58 95.25,113.05 95.25,100.34 92.71,97.81 v92.71,56.53 | v66.04,49.55 64.77,48.27 v64.77,41.92 | v57.78,40.02 57.78,33.04 57.15,32.4 57.15,22.24 56.52,21.61 56.52,20.97 59.69,17.8 IC35.11 | v53.34,115.58 IC14.6
  Bottom 0.254: v53.34,115.58 53.98,116.22 62.23,116.22 67.31,121.3 87,121.3 v87.63,120.67 | v92.71,56.53 88.9,52.72 77.47,52.72 74.3,49.55 v66.04,49.55 | v64.77,41.92 59.69,41.92 v57.78,40.02
PCA  (via drill 0.61)
  Top 0.254: v191.13,104.79 191.13,72.41 193.68,69.86 193.68,32.4 196.85,29.23 200.03,29.23 200.03,22.24 199.39,21.61 196.22,21.61 196.22,14.62 IC37.8
  Bottom 0.254: IC55.5 138.43,12.71 139.7,13.99 195.58,13.99 196.85,12.71 IC37.8 | v191.13,104.79 194.94,104.79 196.85,106.7 IC12.3
PER  (via drill 0.61)  (1 unrouted)
  Top 0.254: v133.35,142.89 133.35,142.25 130.81,139.71 130.81,134.63 132.08,133.36 IC9.9 | v196.22,142.25 201.93,136.54 201.93,78.75 202.56,78.12 202.56,62.88 200.66,60.98 | IC30.2 200.66,60.98 | v27.3,34.3 27.94,33.67 27.94,12.08 38.1,1.92 87,1.92 87,19.07 v86.36,19.7 | v200.03,19.07 200.66,19.7 200.66,60.98 | v147.32,161.94 149.22,161.94 IC49.8 | v69.85,161.3 64.77,166.38 59.05,166.38 53.34,160.67 53.34,159.4 54.61,158.13 SV3.21
  Bottom 0.254: v133.35,142.89 143.51,142.89 144.15,142.25 v196.22,142.25 | v27.3,34.3 33.66,34.3 34.92,35.58 SV1.21 | v86.36,19.7 107.31,19.7 107.95,20.34 119.38,20.34 120.65,19.07 173.99,19.07 174.62,19.7 196.22,19.7 196.85,19.07 v200.03,19.07 | v147.32,161.94 146.05,160.67 146.05,156.86 145.41,156.22 74.93,156.22 v69.85,161.3
PER\  (via drill 0.61)
  Top 0.254: v142.88,132.09 142.88,121.3 144.15,120.03 v144.15,104.16
  Bottom 0.254: v144.15,104.16 144.78,104.79 181.61,104.79 182.88,103.52 197.49,103.52 IC12.4 | v142.88,132.09 IC9.8
PIE  (via drill 0.61)  (1 unrouted)
  Top 0.254: v173.35,3.83 177.16,7.63 177.16,8.27 177.8,8.91 INTENB.2 | v145.41,3.83 140.34,8.91 v140.34,15.26 | v206.38,32.4 206.38,33.04 203.84,35.58 203.84,51.45 IC30.17
  Bottom 0.254: SV1.5 62.23,15.26 64.14,17.16 80.64,17.16 81.28,17.8 114.3,17.8 115.57,16.53 134.62,16.53 135.89,15.26 IC55.4 v140.34,15.26 | v145.41,3.83 v173.35,3.83 173.99,3.19 176.53,3.19 177.8,4.46 205.1,4.46 207.65,7 210.19,7 210.19,28.59 v206.38,32.4 | IC40.8 38.1,162.57 34.92,162.57 33.02,160.67 33.02,159.4 34.29,158.13 SV3.5
PROTECT
  Bottom 0.254: IC5.6 133.99,135.27 150.5,135.27 IC6.3
SETNXD\  (via drill 0.61)
  Top 0.254: v62.87,95.9 v62.87,102.89 | v95.25,94.63 95.25,29.23 100.33,24.14 100.33,10.18 101.6,8.91 IC23.4
  Bottom 0.254: v62.87,102.89 59.69,102.89 IC21.9 | v62.87,95.9 64.14,94.63 71.75,94.63 72.39,94 84.45,94 85.09,94.63 v95.25,94.63
SETPER\  (via drill 0.61)
  Top 0.254: v24.13,128.92 24.13,114.31 22.86,113.05 IC13.5 | v114.3,127.65 113.67,128.28 113.67,138.44 118.11,142.89 118.11,147.97 120.65,150.51 128.27,150.51 128.27,134.63 129.54,133.36 IC9.10
  Bottom 0.254: v24.13,128.92 24.77,128.28 113.67,128.28 v114.3,127.65
SETWLS\  (via drill 0.61)
  Top 0.254: v161.29,127.02 161.29,134.63 162.56,135.9 IC6.7 | v130.18,127.65 IC9.4
  Bottom 0.254: v130.18,127.65 130.81,127.02 v161.29,127.02
SKIP\  (via drill 0.61)
  Top 0.254: IC19.6 185.42,90.19 182.88,92.72 IC19.10 v182.88,105.42 | v124.46,105.42 IC17.2
  Bottom 0.254: R1.1 170.81,86.38 171.45,87.01 173.35,87.01 IC19.2 177.16,87.01 183.51,87.01 IC19.6 | v124.46,105.42 125.09,104.79 142.24,104.79 142.88,105.42 v182.88,105.42
START\  (via drill 0.61)
  Top 0.254: 131.44,45.1 131.44,14.62 DMA0-3.11 | 131.44,45.1 DMA4-7.11 | 131.44,45.1 131.44,79.39 DMA8-11.11 | v154.31,107.97 154.31,109.87 154.94,110.5 IC18.3 | v139.06,107.97 137.16,106.06 137.16,96.53 133.99,93.36 133.99,81.93 v133.35,81.3
  Bottom 0.254: v154.31,107.97 153.67,107.33 149.86,107.33 148.59,108.6 139.7,108.6 v139.06,107.97 | v133.35,81.3 DMA8-11.11
VCC  (via drill 0.61)  (3 unrouted)
  Top 0.508: C14.1 38.73,118.12 40.01,119.39 IC14.14 40.64,118.12 41.91,116.86 41.91,106.7 | 41.91,106.7 40.64,105.42 IC21.16 | 41.91,106.7 45.72,110.5 IC14.3 | C13.1 10.16,117.49 7.62,114.95 IC20.20 | IC1.16 7.62,146.06 10.16,148.6 33.02,148.6 C2.1 | C20.1 5.08,103.52 3.81,104.79 3.81,141.62 5.08,142.89 C1.1 | IC36.6 96.52,21.61 93.98,19.07 IC23.14 | C29.1 81.28,64.15 80.01,62.88 80.01,51.45 81.28,50.18 C32.1 81.28,48.91 82.55,47.64 82.55,33.04 83.82,31.77 IC36.16 v83.82,26.69 | IC25.16 83.82,76.22 85.09,74.95 85.09,72.41 83.82,71.14 IC29.16 | 90.17,116.22 90.17,104.79 91.44,103.52 C33.1 | 90.17,116.22 91.44,117.49 C16.1 | 73.03,113.68 73.66,113.05 IC15.3 | v73.03,116.22 73.03,113.68 | 64.77,123.2 64.77,126.38 62.23,126.38 59.69,128.92 59.69,141.62 60.96,142.89 C3.1 | 64.77,123.2 66.04,121.94 76.83,121.94 76.83,121.3 77.47,120.67 77.47,118.12 73.03,113.68 | 90.17,116.22 87.63,116.22 v87.63,116.86 | IC35.20 59.69,41.92 C35.1 | v46.35,13.99 46.35,8.91 45.72,8.27 R2.2 | C41.1 v63.5,39.38 63.5,60.98 | IC34.20 24.13,41.92 C34.1 | IC26.20 24.13,74.95 C26.1 | v20.32,73.67 v20.32,44.47 | 63.5,60.98 63.5,71.14 IC28.20 59.69,74.95 C28.1 60.33,76.22 v60.33,107.97 60.33,121.94 63.5,121.94 64.77,123.2 | 63.5,60.98 v64.14,60.98 | IC38.20 158.75,31.77 C38.1 | IC55.14 143.51,24.14 C40.1 | v166.37,30.5 166.37,13.99 169.54,13.99 172.09,16.53 C43.1 | C44.1 204.47,90.19 FIELD.16 203.84,87.01 203.84,63.52 C30.1 204.47,62.24 IC30.20 203.2,58.44 203.2,34.94 204.47,33.67 C37.1 204.47,31.77 IC37.20 | J7.2 177.8,41.29 175.9,43.2 175.9,43.83 177.8,45.73 J5.2 J4.2 J3.2 v177.8,60.98 | C31.1 158.75,66.06 IC31.20 158.75,64.78 v154.94,60.98
  Top 0.508: 127,60.34 v126.36,59.7 | 127,60.34 127,61.61 127.64,62.24 C39.1 | 127,60.34 127,40.66 127.64,40.02 127.64,29.23 128.27,28.59 C46.1 | IC18.14 149.86,120.67 148.59,121.94 148.59,129.55 147.32,130.82 IC10.14 | IC6.16 147.32,143.52 146.69,142.89 146.69,139.08 146.05,138.44 146.05,134.63 144.78,133.36 C10.1 | IC17.16 121.92,120.67 120.65,121.94 120.65,129.55 119.38,130.82 IC9.14 119.38,133.36 120.65,134.63 120.65,139.08 119.38,140.35 IC5.14 | v91.44,140.98 IC4.16 | DMA8-11.16 128.27,95.27 C8.1 | C27.1 143.51,95.27 DAR8-11.16 142.24,91.45 142.24,64.15 143.51,62.88 C42.1 | IC24.20 158.75,100.34 C24.1 | R1.2 IC19.14 C19.1 172.72,99.71 173.35,100.34 173.35,111.78 173.99,112.41 173.99,114.95 172.72,116.22 C11.1 | C48.1 208.28,130.19 207.01,131.46 207.01,132.09 IC8.8 203.84,130.19 203.84,118.12 204.47,117.49 C12.1 204.47,113.05 IC12.14 | RL.1 RA.1 198.12,120.03 199.39,121.3 199.39,123.2 IC8.4 | IC11.4 182.88,113.05 185.42,115.58 IC11.10 | IC7.16 172.72,130.82 173.99,129.55 173.99,121.94 175.26,120.67 IC11.14 | v118.75,115.58 119.38,116.22 C17.1 | D6.A 222.25,116.86 220.98,118.12 RF08B.2 | D1.A 222.25,5.09 220.98,6.36 RF08A.2 | 113.67,195.59 106.68,195.59 104.14,193.05 IC56.20 96.52,193.05 95.89,193.69 95.89,194.96 99.69,198.77 147.96,198.77 153.67,193.05 IC48.20 160.02,193.05 162.56,195.59 169.54,195.59 | 113.67,195.59 RN1.1 | 113.67,195.59 113.67,193.69 IC47.20 | 169.54,195.59 RN2.1 | 169.54,195.59 169.54,193.69 IC49.20 | IC40.20 59.69,193.05 62.23,195.59 RN4.1 | SV3.26 SV3.25 | 41.27,194.96 36.83,199.4 16.51,199.4 12.7,195.59 RN3.1 | 41.27,194.96 IC33.20 48.26,193.05 49.53,194.32 v55.88,194.32
  Top 0.508: v50.16,168.29 49.53,168.29 48.9,167.65 43.18,167.65 41.27,169.56 41.27,194.96 | v80.64,189.24 67.31,189.24 v66.67,188.61
  Bottom 0.508: IC21.16 40.01,103.52 39.37,103.52 38.73,102.89 C21.1 38.1,102.25 44.45,102.25 | 44.45,102.25 52.07,102.25 52.07,105.42 52.7,106.06 62.23,106.06 65.41,102.89 C22.1 66.67,102.89 67.31,103.52 67.94,103.52 IC22.14 68.58,105.42 66.04,107.97 v60.33,107.97 | C13.1 10.79,118.12 11.43,118.76 12.06,118.76 IC13.14 | C20.1 5.71,102.89 6.35,103.52 6.99,103.52 IC20.20 7.62,106.7 | 7.62,106.7 7.62,112.41 9.53,114.31 15.24,114.31 IC13.3 | C1.1 5.71,143.52 6.35,144.16 6.99,144.16 IC1.16 | C2.1 33.66,143.52 34.29,144.16 34.92,144.16 IC2.16 | 44.45,102.25 44.45,106.7 7.62,106.7 | C23.1 92.08,13.99 92.71,14.62 93.34,14.62 IC23.14 | C25.1 81.92,80.03 82.55,80.66 83.19,80.66 IC25.16 | IC29.16 83.19,65.42 82.55,65.42 81.92,64.78 C29.1 80.64,64.78 78.11,62.24 70.48,62.24 69.85,61.61 64.77,61.61 v64.14,60.98 | C36.1 81.92,29.23 82.55,29.86 83.19,29.86 IC36.16 | C32.1 81.92,49.55 82.55,50.18 83.19,50.18 IC32.16 | v83.82,26.69 92.71,26.69 IC36.6 | C16.1 92.71,118.12 IC16.16 97.79,115.58 v118.75,115.58 | C3.1 61.59,143.52 62.23,144.16 62.87,144.16 IC3.16 | 72.39,116.86 71.75,117.49 68.58,117.49 | 72.39,116.86 v73.03,116.22 | 68.58,117.49 66.04,117.49 C15.1 | 68.58,117.49 IC15.14 | v87.63,116.86 72.39,116.86 | v46.35,13.99 C41.1 64.77,13.99 IC41.16 | v63.5,39.38 62.23,40.66 IC35.20 | SV1.25 SV1.26 IC34.20 | 47.62,72.41 46.35,71.14 RS08.2 | 47.62,72.41 57.15,72.41 58.42,73.67 IC28.20 | 47.62,72.41 27.94,72.41 26.67,73.67 IC26.20 v20.32,73.67 | v20.32,44.47 22.23,44.47 23.5,43.2 C34.1 | C43.1 173.35,16.53 173.99,17.16 174.62,17.16 INTENB.16 | C46.1 128.27,27.32 129.54,26.05 DMA0-3.16 130.81,25.41 132.72,27.32 140.97,27.32 141.6,26.69
  Bottom 0.508: 141.6,26.69 142.88,25.41 C40.1 | 141.6,26.69 154.94,26.69 158.75,30.5 IC38.20 | v166.37,30.5 163.83,33.04 C38.1 | C39.1 128.91,62.24 129.54,61.61 137.16,61.61 137.79,60.98 141.6,60.98 142.88,62.24 C42.1 143.51,61.61 144.15,61.61 144.15,60.98 | v126.36,59.7 DMA4-7.16 | 144.15,60.98 144.15,60.34 DAR4-7.16 | 144.15,60.98 v154.94,60.98 161.29,60.98 162.56,62.24 176.53,62.24 v177.8,60.98 186.06,60.98 187.32,59.7 191.13,59.7 193.68,62.24 202.56,62.24 203.84,63.52 C30.1 | C6.1 145.41,143.52 146.05,144.16 146.69,144.16 IC6.16 | C18.1 147.96,118.12 148.59,118.76 149.22,118.76 IC18.14 | C17.1 120.02,118.12 120.65,118.76 121.28,118.76 IC17.16 | IC9.14 118.75,131.46 118.11,131.46 117.47,130.82 C9.1 116.84,130.19 143.51,130.19 144.15,130.82 C10.1 145.41,130.82 146.05,131.46 146.69,131.46 IC10.14 149.22,130.19 158.12,130.19 158.75,130.82 158.75,134.63 189.87,134.63 194.31,139.08 C45.+ 196.22,138.44 205.74,138.44 IC8.8 | C4.1 89.53,143.52 90.17,144.16 90.81,144.16 IC4.16 | IC5.14 118.75,144.16 118.11,144.16 117.47,143.52 C5.1 114.3,143.52 112.39,141.62 92.08,141.62 v91.44,140.98 | C8.1 128.91,96.53 129.54,95.9 137.16,95.9 137.79,95.27 141.6,95.27 142.88,96.53 C27.1 144.15,96.53 144.78,97.17 150.5,97.17 151.13,97.81 155.57,97.81 156.84,99.08 IC24.20 C19.1 | C12.1 203.84,114.31 198.75,119.39 RA.1 | C7.1 170.81,130.82 171.45,131.46 172.09,131.46 IC7.16 | C11.1 173.35,118.12 173.99,118.76 174.62,118.76 IC11.14 177.16,121.3 180.34,121.3 | 180.34,121.3 183.51,121.3 IC11.10 187.32,117.49 193.04,117.49 194.94,119.39 RL.1 | v50.16,168.29 50.16,165.75 53.98,161.94 57.15,161.94 59.05,160.03 SV3.26
  Bottom 0.508: v55.88,194.32 57.15,193.05 IC40.20 | v80.64,189.24 85.72,189.24 88.27,191.78 93.98,191.78 95.25,193.05 IC56.20 | v66.67,188.61 66.67,192.42 RN4.1 | 180.34,121.3 IC11.12
WE\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v47.62,75.58 46.99,74.95 46.99,65.42 45.72,64.15 RS08.8 | v78.74,80.66 IC22.5 v81.92,99.71 | v135.89,139.08 135.89,109.23 126.36,99.71 123.83,99.71 v123.83,98.44
  Bottom 0.254: v78.74,80.66 52.7,80.66 v47.62,75.58 | v135.89,139.08 136.53,139.71 154.94,139.71 IC6.5 | v123.83,98.44 123.19,99.08 90.81,99.08 90.17,98.44 83.19,98.44 v81.92,99.71 | RF08A.8 221.62,15.26 222.88,13.99 224.16,13.99 224.79,14.62 231.78,14.62 232.41,15.26 IC42.29 246.38,15.26 247.65,13.99 250.19,13.99 250.82,14.62 253.37,14.62 254,15.26 IC43.29 | RF08B.8 221.62,127.02 222.88,125.75 224.16,125.75 224.79,126.38 231.78,126.38 232.41,127.02 IC39.29 246.38,127.02 247.65,125.75 250.19,125.75 250.82,126.38 254.63,126.38 255.27,127.02 IC45.29
WLS  (via drill 0.61)  (1 unrouted)
  Top 0.254: v203.2,22.88 202.56,22.24 202.56,3.19 203.84,1.92 206.38,1.92 206.38,4.46 210.82,8.91 210.82,130.19 190.5,150.51 130.81,150.51 130.81,140.98 v130.18,140.35 | v132.08,139.71 133.35,138.44 133.35,129.55 129.54,125.75 IC9.5 | v39.37,29.23 38.73,29.86 38.73,45.1 40.64,47.01 40.64,48.27 39.37,49.55 38.1,49.55 38.1,47.01 37.47,46.37 37.47,15.89 v40.64,12.71 | v71.12,12.71 72.39,13.99 72.39,19.7 75.56,22.88 v75.56,31.77 | v138.43,34.3 147.32,25.41 v147.32,20.34 | v100.33,195.59 v102.87,195.59 | v95.25,196.86 92.71,196.86 90.81,198.77 82.55,198.77 v81.92,198.13 | v41.27,198.13 40.01,198.13 v39.37,198.77 | v24.77,157.49 27.3,157.49 28.57,156.22 45.09,156.22 46.35,157.49 SV3.15
  Bottom 0.254: v130.18,140.35 130.81,139.71 v132.08,139.71 | v203.2,22.88 IC37.4 196.85,22.88 195.58,24.14 182.25,24.14 179.71,21.61 151.13,21.61 150.5,20.97 147.96,20.97 v147.32,20.34 | v39.37,29.23 37.47,29.23 36.2,27.96 SV1.15 | v40.64,12.71 41.91,11.45 69.85,11.45 v71.12,12.71 | v75.56,31.77 78.11,34.3 v138.43,34.3 | v102.87,195.59 102.87,187.97 104.78,186.07 104.78,184.8 105.41,184.16 107.95,184.16 108.58,183.53 108.58,182.26 110.49,180.35 IC47.15 | v100.33,195.59 96.52,195.59 v95.25,196.86 | v81.92,198.13 v41.27,198.13 | v39.37,198.77 19.05,198.77 13.34,193.05 13.34,168.92 v24.77,157.49
WLS\  (via drill 0.61)
  Top 0.254: v133.35,107.97 133.35,121.94 132.08,123.2 IC9.6 | v148.59,107.33 151.76,107.33 v151.76,108.6
  Bottom 0.254: v133.35,107.97 134.62,106.7 147.96,106.7 v148.59,107.33 | v151.76,108.6 152.4,109.23 195.58,109.23 196.85,110.5 203.2,110.5 204.47,109.23 IC12.13
WRITING  (via drill 0.61)  (3 unrouted)
  Top 0.254: IC6.2 151.76,135.27 158.75,135.27 158.75,127.02 157.48,125.75 IC10.5 | RS08.18 45.09,50.81 45.09,49.55 42.55,49.55 41.91,48.91 41.91,21.61 v40.64,20.34 43.18,17.8 43.18,5.09 61.59,5.09 64.77,8.27 64.77,8.91 67.31,11.45 67.31,20.34 67.94,20.34 | 67.94,20.34 68.58,20.34 69.85,19.07 69.85,17.8 71.12,16.53 IC41.14 | v174.62,116.22 176.53,114.31 176.53,45.73 173.99,43.2 v173.99,34.3 | v118.11,33.04 116.2,31.13 v116.2,30.5 | v69.85,31.77 67.94,29.86 67.94,20.34 | v45.09,194.32 50.16,199.4 93.98,199.4 96.52,196.86 95.25,195.59 92.71,195.59 90.81,197.5 89.53,196.23 89.53,187.34 90.17,186.7 92.71,186.7 96.52,182.89 93.98,180.35 IC56.6 | v40.01,194.32 38.1,196.23 38.1,196.86 36.83,198.13 v17.14,198.13
  Bottom 0.254: IC41.14 71.75,14.62 73.03,14.62 IC41.13 | v40.64,20.34 SV1.9 | v174.62,116.22 172.72,116.22 167.64,121.3 160.66,121.3 IC10.5 | v173.99,34.3 145.41,34.3 144.15,33.04 v118.11,33.04 | v116.2,30.5 114.94,29.23 102.87,29.23 101.6,27.96 78.11,27.96 74.3,31.77 v69.85,31.77 | RF08A.18 221.62,27.96 222.88,26.69 224.16,26.69 224.79,27.32 231.78,27.32 232.41,27.96 IC42.24 245.11,27.96 246.38,26.69 250.19,26.69 250.82,27.32 253.37,27.32 254,27.96 IC43.24 | RF08B.18 221.62,139.71 222.88,138.44 224.16,138.44 224.79,139.08 231.78,139.08 232.41,139.71 IC39.24 245.11,139.71 246.38,138.44 250.19,138.44 250.82,139.08 254.63,139.08 255.27,139.71 IC45.24 | v45.09,194.32 v40.01,194.32 | v17.14,198.13 12.06,193.05 12.06,168.92 24.77,156.22 37.47,156.22 38.73,157.49 SV3.9

## Text on the board
Bottom: RS08 | VRS | RF08 Debug | VRS | RS08 | VRS | RF08 | VRS
tPlace: RF08 | VRS
tValues: RF08 Debug | VRS | RS08 | VRS | RS08 | VRS